Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2017-06-30T11:33:04
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.5.0.0 - Interface alternative d'export 16.5.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jun 30 11:33:04 2017 * Host: LTBATREI25067 * Database: C:\Users\Blond\AppData\Local\Temp\{159A2C5A-81DA-4143-B7F7-89D2BACEB8B3}\ifc * Database version: 5507 * Database creation date: Fri Jun 30 11:33:03 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jun 30 11:33:03 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jun 30 11:33:03 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: BWT 4ème serie; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 52, 0, 117187; RefLongitude: 2, 19, 59, 880409; RefElevation: 0 mm
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: BWT 4ème serie; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: BWT 4ème serie; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Centre; Symbole: Marqueur de niveau - Cercle: Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Pointe 8 mm
Autre - Catégorie: Niveaux; Famille: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; ID du type: Niveau: Pointe 8 mm; Type: Niveau: Pointe 8 mm
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet

# IfcFlowTerminal: LMIJ25, BWT_LMIJ_12-75:LMIJ25:229066
In: Niveau 1
Material: Plastique noir, Plastique gris, Stratifié, bleu marine, BWT_Plastique noir, INOX
Pset_ManufacturerTypeInformation - Manufacturer: BWT_FRANCE
Pset_DistributionFlowElementCommon - Reference: LMIJ25
Autre - Catégorie: Appareils sanitaires; Famille: BWT_LMIJ_12-75: LMIJ25; Famille et type: BWT_LMIJ_12-75: LMIJ25; ID du type: BWT_LMIJ_12-75: LMIJ25; Type: BWT_LMIJ_12-75: LMIJ25
Contraintes - Décalage: 0 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1
Cotes - Surface: 0.655968 m2; Volume: 46.1751 dm3
Données d'identification - Identifiant: 29
Génie climatique - Classification du système: Retour hydraulique,Alimentation hydraulique
Phase de construction - Phase de création: Phase 1
Autre(Type) - Catégorie: Appareils sanitaires; Nom de la famille: BWT_LMIJ_12-75; Visibilité LOGO 1: no; Visibilité LOGO 2: yes
Contraintes(Type) - Hauteur Col: 85 mm; Hauteur logo: 600 mm; Profondeur logo: 89.7587 mm
Cotes(Type) - BWT_Hauteur: 1180 mm; BWT_Largeur: 220 mm; BWT_Profondeur: 220 mm
Données d'identification(Type) - Fabricant: BWT_FRANCE; Modèle: LMIJ25; Nom du type: LMIJ25; URL: http:\\www.bwt.fr
Données(Type) - BWT_CODE: PK0004463; BWT_Débit de production: 0.00735722 m3/s; BWT_DN de raccordement: 15 mm; BWT_Masse en service (Vide): 8; BWT_Pression conseillée: 3-5 bar; BWT_Température maxi de l'ambiance: 35 kg/K/s3; BWT_Température maxi eau: 50 kg/K/s3; BWT_Température min de l'ambiance: 5 kg/K/s3; BWT_Température mini eau: 2 kg/K/s3; BWT_Tension électrique: 0 V; BWT_Volume de résine: 25 dm3
Matériaux et finitions(Type) - Matériau: INOX; Matériau 2: BWT_Plastique noir
