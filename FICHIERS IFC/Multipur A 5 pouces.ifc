Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2017-03-22T15:57:06
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.5.0.0 - Interface alternative d'export 16.5.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 22 15:57:06 2017 * Host: LTBATREI25067 * Database: C:\Users\Blond\AppData\Local\Temp\{A96BAB0E-D938-4786-B127-6598F8221D68}\ifc * Database version: 5507 * Database creation date: Wed Mar 22 15:57:06 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 22 15:57:06 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 22 15:57:06 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: BWT 3eme Serie

# IfcSite, Default
RefLatitude: 48, 51, 23, 807373; RefLongitude: 2, 21, 7, 999076; RefElevation: 0 mm
Autre - Catégorie: Informations sur le projet; Nom du client: BWT; Nom du projet: BWT 3eme Serie; Numéro de projet: 0001

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Nom du client: BWT; Nom du projet: BWT 3eme Serie; Numéro de projet: 0001

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Plein; Symbole: Marqueur de niveau - Cercle: Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Pointe 8 mm
Autre - Catégorie: Niveaux; Famille: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; ID du type: Niveau: Pointe 8 mm; Type: Niveau: Pointe 8 mm
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 0; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet

# IfcFlowTerminal: Multipur AP5", BWT_Multipur AP:Multipur AP5":714378
In: Niveau 0
Material: Verre opaque, UHMW, noir, Laiton, BWT_Plastique noir, BWT_Plastique bleu, BWT_Cuivre
Pset_ManufacturerTypeInformation - Manufacturer: BWT_FRANCE
Pset_DistributionFlowElementCommon - Reference: Multipur AP5"
Autre - Catégorie: Appareils sanitaires; Famille: BWT_Multipur AP: Multipur AP5"; Famille et type: BWT_Multipur AP: Multipur AP5"; ID du type: BWT_Multipur AP: Multipur AP5"; Type: BWT_Multipur AP: Multipur AP5"
Contraintes - Décalage: 1040 mm; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0
Cotes - Surface: 0.35474 m2; Volume: 0.0162903 m3
Données d'identification - Identifiant: 3
Génie climatique - Classification du système: Alimentation hydraulique; Nom du système: Chauffage aller 3; Type de système: Système de canalisation: Chauffage aller
Phase de construction - Phase de création: Nouvelle construction
Autre(Type) - Catégorie: Appareils sanitaires; Nom de la famille: BWT_Multipur AP
Cotes(Type) - BWT_Hauteur: 770 mm; BWT_Largeur: 220 mm; Diamètre bride: 110 mm; Hauteur thermomètre: 90 mm
Données d'identification(Type) - Fabricant: BWT_FRANCE; Modèle: Multipur A5"; Nom du type: Multipur AP5"; URL: http:\\www.bwt.fr
Données(Type) - BWT_CODE: PK0033944A; BWT_Consommation électrique normale: 230 W; BWT_Débit maximal: 0.0211111 m3/s; BWT_DN de raccordement: 125 mm; BWT_Element filtrant: Tamis; BWT_Masse en service: 33; BWT_Matériau: Laiton; BWT_Pression maximum: 1100000 Pa; BWT_Pression minimum: 250000 Pa; BWT_Seuil de filtration: 90 µm; BWT_Température maxi eau: 30 kg/K/s3; BWT_Température max local: 40 kg/K/s3; BWT_Température mini eau: 5 kg/K/s3; BWT_Température min local: 5 kg/K/s3; BWT_Tension électrique: 12 V; BWT_Type de raccordement: Bride
Matériaux et finitions(Type) - Matériau 1: BWT_Plastique noir; Matériau 3: BWT_Plastique bleu; Matériau 4: BWT_Cuivre
