Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2017-03-22T13:58:33
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.5.0.0 - Interface alternative d'export 16.5.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 22 13:58:33 2017 * Host: LTBATREI25067 * Database: C:\Users\Blond\AppData\Local\Temp\{75D17908-1E43-4D8F-A313-E43A1CFFB937}\ifc * Database version: 5507 * Database creation date: Wed Mar 22 13:58:32 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 22 13:58:32 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 22 13:58:32 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: C:\Users\Blond\Desktop\Export IFC\Adouccisseur\FR\7050 SC.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Autre - Catégorie: Informations sur le projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Autre - Catégorie: Niveaux; Famille: Niveau: Niveau 1; Famille et type: Niveau: Niveau 1; ID du type: Niveau: Niveau 1; Type: Niveau: Niveau 1
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet
Données d'identification(Type) - Nom du type: Niveau 1
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Plein; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes

# IfcDistributionPort (12)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
InPort_2314
2 x OutPort_2319
InPort_2316
2 x OutPort_2321
2 x InPort_2318
InPort_2318 | Group: Eau froide sanitaire 2
OutPort_2325 | Group: Eau froide sanitaire 2
InPort_2318 | Group: Eau froide sanitaire 1
OutPort_2323 | Group: Eau froide sanitaire 1

# IfcFlowController: BWT_Simply-connect Coudée, BWT_Simply-connect Coudée:BWT_Simply-connect Coudée:2318
In: Niveau 1
Type - Material: INOX, Laiton, Acier, Par défaut
Type - Autre(Type) - Catégorie: Accessoire de canalisation; Nom de la famille: BWT_Simply-connect Coudée
Type - Données d'identification(Type) - Fabricant: BWT; Modèle: Simply connect; Nom du type: BWT_Simply-connect Coudée
Type - Données(Type) - BWT_DN de raccordement: 50 mm
Pset_ManufacturerTypeInformation - Manufacturer: BWT
Pset_DistributionFlowElementCommon - Reference: BWT_Simply-connect Coudée
Autre - Catégorie: Accessoire de canalisation; Famille: BWT_Simply-connect Coudée: BWT_Simply-connect Coudée; Famille et type: BWT_Simply-connect Coudée: BWT_Simply-connect Coudée; ID du type: BWT_Simply-connect Coudée: BWT_Simply-connect Coudée; Type: BWT_Simply-connect Coudée: BWT_Simply-connect Coudée
Contraintes - Niveau: Niveau: Niveau 1; Décalage: 1500 mm; Hôte: Niveau : Niveau 1
Cotes - Surface: 0.142759 m2; Taille: 50 mmø-50 mmø-50 mmø-50 mmø; Taille maximale: 50 mm; Taille minimale: 50 mm; Volume: 0.00182495 m3
Données d'identification - Identifiant: 193
Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau froide sanitaire 1,Eau froide sanitaire 2; Type de système: Système de canalisation: Eau froide sanitaire
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 50 mmø-50 mmø-50 mmø-50 mmø
Phase de construction - Phase de création: Nouvelle construction
Group: Eau froide sanitaire 2; Eau froide sanitaire 1

# IfcFlowFitting: BWT_Raccord Aval (2)
In: Niveau 1
Type - Material: Laiton
Type - Autre(Type) - Catégorie: Raccords de canalisation; Nom de la famille: BWT_Raccord Aval
Type - Données d'identification(Type) - Fabricant: BWT; Modèle: Simply connect; Nom du type: BWT_Raccord Aval
Type - Données(Type) - BWT_DN de raccordement: 50 mm
Pset_ManufacturerTypeInformation - Manufacturer: BWT
Pset_DistributionFlowElementCommon - Reference: BWT_Raccord Aval
Autre - Catégorie: Raccords de canalisation; Famille: BWT_Raccord Aval: BWT_Raccord Aval; Famille et type: BWT_Raccord Aval: BWT_Raccord Aval; ID du type: BWT_Raccord Aval: BWT_Raccord Aval; Type: BWT_Raccord Aval: BWT_Raccord Aval
Contraintes - Niveau: Niveau: Niveau 1; Hôte: Niveau : Niveau 1
Cotes - Surface: 0.0103433 m2; Taille: 50 mmø-50 mmø; Taille maximale: 50 mm; Taille minimale: 50 mm; Volume: 0.0000448394 m3
Génie climatique - Classification du système: Eau froide sanitaire
Graphismes - Utiliser l'échelle d'annotations: no
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 50 mmø-50 mmø
Phase de construction - Phase de création: Nouvelle construction
Name (BWT_Raccord Aval:BWT_Raccord Aval:...) | Décalage (mm) | Identifiant
2314 | 1184.2 | 67
2316 | 1185.13 | 68

# IfcFlowSegment: Canalisation souple arrondie:Souple - Circulaire (2)
In: Niveau 1
Autre - Catégorie: Canalisation souple; Famille: Canalisation souple arrondie: Souple - Circulaire; Famille et type: Canalisation souple arrondie: Souple - Circulaire; ID du type: Canalisation souple arrondie: Souple - Circulaire; Type: Canalisation souple arrondie: Souple - Circulaire; sets with these values: 2
Contraintes - Niveau de référence: Niveau: Niveau 1
Cotes - Diamètre extérieur: 50 mm; Diamètre intérieur: 50 mm; sets with these values: 2
Données d'identification - sets with these values: 2
Génie climatique - Classification du système: Non défini; Diamètre: 50 mm
Génie climatique - Ecoulement - Etat du flux: Laminaire; Facteur de frottement: 0; Flux: 0 m3/s; Flux supplémentaire: 0 m3/s; Frottement: 0; Nombre de Reynolds: 0; Perte de charge: 0 Pa; Rugosité relative: 0.0009144; Unités du dispositif: 0; Vitesse: 0 m/s
Graphismes - Modèle de gaine flexible: A voie unique; sets with these values: 2
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 50 mmø; sets with these values: 2
Phase de construction - Phase de création: Nouvelle construction; sets with these values: 2
Pset_DistributionFlowElementCommon - Reference: Souple - Circulaire
Autre(Type) - Catégorie: Canalisation souple; Nom de la famille: Canalisation souple arrondie
Données d'identification(Type) - Nom du type: Souple - Circulaire
Génie climatique(Type) - Rugosité: 0.04572 mm
Raccords(Type) - Té: Té - Générique: Standard; Transition: Transformation - Générique: Standard; Type de jonction préférée: Té; Union: Manchon - Générique: Standard
Name (Canalisation souple arrondie:Souple - Circulaire:...) | Décalage de départ (mm) | Longueur (mm) | Identifiant | Coupe
2319 | 1184.2 | 498.799 | 32 | 2
2321 | 1185.12 | 498.614 | 33 | 0 | Contraintes - sets with these values: 2; Génie climatique - Ecoulement - sets with these values: 2

# IfcFlowSegment: Canalisation:Standard (2)
In: Niveau 1
Autre - Catégorie: Canalisation; Famille: Canalisation: Standard; Famille et type: Canalisation: Standard; ID du type: Canalisation: Standard; Type: Canalisation: Standard; sets with these values: 2
Contraintes - Niveau de référence: Niveau: Niveau 1; Décalage de départ: 1500 mm; Décalage extrémité: 1500 mm; Décaler: 1500 mm; Inclinaison: 0; Justification horizontale: Centre; Justification verticale: Milieu
Cotes - Diamètre extérieur: 60.325 mm; Diamètre intérieur: 52.5018 mm; Longueur: 200 mm; Taille: 50 mmø; sets with these values: 2
Données d'identification - sets with these values: 2
Génie climatique - Type de système: Système de canalisation: Eau froide sanitaire; Classification du système: Eau froide sanitaire; Coupe: 1; Diamètre: 50 mm; Inverser l'élévation: 1473.75 mm; Matériau: Acier, carbone; Nomenclature/type: Types de nomenclatures de canalisations: Nomenclature 40; Rugosité: 0.04572 mm; Segment de canalisation: Acier au carbone - Série 40; Surface: 0.0314159 m2; Type de connexion: Générique
Génie climatique - Ecoulement - Etat du flux: Laminaire; Facteur de frottement: 0; Frottement: 0; Nombre de Reynolds: 0; Unités du dispositif: 0; Flux: 0 m3/s; Flux supplémentaire: 0 m3/s; Perte de charge: 0 Pa; Rugosité relative: 0.000870827; Vitesse: 0 m/s; sets with these values: 2
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 50 mmø; sets with these values: 2
Phase de construction - Phase de création: Nouvelle construction; sets with these values: 2
Pset_DistributionFlowElementCommon - Reference: Standard
Autre(Type) - Catégorie: Canalisation; Nom de la famille: Canalisation
Données d'identification(Type) - Nom du type: Standard
Name (Canalisation:Standard:...) | Identifiant | Nom du système = Group
2323 | 278 | Eau froide sanitaire 1
2325 | 279 | Eau froide sanitaire 2 | Contraintes - sets with these values: 2; Génie climatique - sets with these values: 2

# IfcFlowTerminal: 7050SC, BWT_7000SC:7050SC:2312
In: Niveau 1
Material: Plastique, noir opaque, Plastique, blanc opaque, Stratifié, bleu marine, Plastique ABS, UHMW, noir, INOX
Pset_ManufacturerTypeInformation - Manufacturer: BWT
Pset_DistributionFlowElementCommon - Reference: 7050SC
Autre - Catégorie: Appareils sanitaires; Famille: BWT_7000SC: 7050SC; Famille et type: BWT_7000SC: 7050SC; ID du type: BWT_7000SC: 7050SC; Type: BWT_7000SC: 7050SC
Contraintes - Décalage: 0.0410041 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1
Cotes - Surface: 1.54296 m2; Volume: 0.141053 m3
Données - BWT_URL_Produit: http://www.bwt.fr/fr/Documentations/Eau_dconsommation_Humaine/Adoucissement/Pages/default.aspx
Données d'identification - Identifiant: 7
Génie climatique - Classification du système: Eau froide sanitaire
Phase de construction - Phase de création: Nouvelle construction
Autre(Type) - Catégorie: Appareils sanitaires; BWT_Hauteur de raccordment: 1184 mm; BWT_Hauteur Ecran de contrôle: 215 mm; BWT_Hauteur socle: 150 mm; Nom de la famille: BWT_7000SC
Cotes(Type) - BWT_Diamètre: 375 mm; BWT_Hauteur: 1350 mm; BWT_Hauteur bac à sel: 885 mm; BWT_Largeur bac à sel: 410 mm; BWT_Longueur bac à sel: 535 mm
Données d'identification(Type) - Description: Adoucisseur; Fabricant: BWT; Image du type: Image raster: BWT_7000SC.jpg; Modèle: BWT 7050 SC; Nom du type: 7050SC; URL: http:\\www.bwt.fr
Données(Type) - BWT_ACS: yes; BWT_Capacité bac à sel: 135; BWT_Capacité d'échange (°f.m3): 275; BWT_CODE: BK07050SC40; BWT_Consommation électrique en regénération: 50 W; BWT_Consommation électrique normale: 10 W; BWT_Débit à TH0° F: 0.0686674 m3/s; BWT_Débit eau de rejet: 0.0156954 m3/s; BWT_DN de raccordement: 50 mm; BWT_Masse en service: 450; BWT_Origine France Garantie: yes; BWT_Pression maximum: 700000 Pa; BWT_Pression minimum: 150000 Pa; BWT_Température maxi eau: 35 kg/K/s3; BWT_Température max local: 40 kg/K/s3; BWT_Température mini eau: 5 kg/K/s3; BWT_Température min local: 5 kg/K/s3; BWT_Tension électrique: 230 V; BWT_Volume de résine: 0.05 m3
Visibilité(Type) - Bac à sel Carré: yes; Bac à sel Type 1: no; Bac à sel Type 2: no

# IfcFlowTerminal: Bac à sel compact, BWT_Bac à Sel carré:Bac à sel compact:2313
In: Niveau 1
Material: Plastique, noir opaque, Plastique, blanc opaque
Pset_ManufacturerTypeInformation - Manufacturer: BWT
Pset_DistributionFlowElementCommon - Reference: Bac à sel compact
Autre - Catégorie: Appareils sanitaires; Famille: BWT_Bac à Sel carré: Bac à sel compact; Famille et type: BWT_Bac à Sel carré: Bac à sel compact; ID du type: BWT_Bac à Sel carré: Bac à sel compact; Type: BWT_Bac à Sel carré: Bac à sel compact
Contraintes - Décalage: 0 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1; Se déplace avec les éléments voisins: no
Cotes - Surface: 1.23483 m2; Volume: 0.194269 m3
Données d'identification - Identifiant: 138
Phase de construction - Phase de création: Nouvelle construction
Autre(Type) - Catégorie: Appareils sanitaires; Nom de la famille: BWT_Bac à Sel carré
Cotes(Type) - BWT_Diamètre: 220 mm; BWT_Hauteur: 1156 mm
Données d'identification(Type) - Description: Bac à sel compact; Fabricant: BWT; Nom du type: Bac à sel compact; URL: http:\\www.bwt.fr

# IfcSystem: Eau froide sanitaire (2)
Autre - Catégorie: Système de canalisation; Famille: Système de canalisation: Eau froide sanitaire; Famille et type: Système de canalisation: Eau froide sanitaire; ID du type: Système de canalisation: Eau froide sanitaire; Type: Système de canalisation: Eau froide sanitaire
Génie climatique - Unités du dispositif: 0; Nombre d'éléments: 0; Volume: 0.000702903 m3
Génie climatique - Ecoulement - Flux: 0 m3/s
Name | Nom du système
Eau froide sanitaire 2 | Eau froide sanitaire 2
Eau froide sanitaire 1 | Eau froide sanitaire 1
