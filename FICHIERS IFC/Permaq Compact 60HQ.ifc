Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2017-03-22T16:06:33
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.5.0.0 - Interface alternative d'export 16.5.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 22 16:06:33 2017 * Host: LTBATREI25067 * Database: C:\Users\Blond\AppData\Local\Temp\{8A101051-CFDC-4E33-BFF3-D5269BD49739}\ifc * Database version: 5507 * Database creation date: Wed Mar 22 16:06:33 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 22 16:06:33 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 22 16:06:33 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: BWT 3eme Serie

# IfcSite, Default
RefLatitude: 48, 51, 23, 807373; RefLongitude: 2, 21, 7, 999076; RefElevation: 0 mm
Autre - Catégorie: Informations sur le projet; Nom du client: BWT; Nom du projet: BWT 3eme Serie; Numéro de projet: 0001

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Nom du client: BWT; Nom du projet: BWT 3eme Serie; Numéro de projet: 0001

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Plein; Symbole: Marqueur de niveau - Cercle: Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Pointe 8 mm
Autre - Catégorie: Niveaux; Famille: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; ID du type: Niveau: Pointe 8 mm; Type: Niveau: Pointe 8 mm
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 0; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet

# IfcFlowTerminal: Permaq Compact 60HQ, BWT_Permaq Compact HQ:Permaq Compact 60HQ:752920
In: Niveau 0
Material: Stratifié, bleu marine, Plastique ABS, BWT_Plastique noire, BWT_Ecran, BWT_Plastique gris, BWT_Métal
Pset_ManufacturerTypeInformation - Manufacturer: BWT_FRANCE
Pset_DistributionFlowElementCommon - Reference: Permaq Compact 60HQ
Autre - Catégorie: Appareils sanitaires; Famille: BWT_Permaq Compact HQ: Permaq Compact 60HQ; Famille et type: BWT_Permaq Compact HQ: Permaq Compact 60HQ; ID du type: BWT_Permaq Compact HQ: Permaq Compact 60HQ; Type: BWT_Permaq Compact HQ: Permaq Compact 60HQ
Contraintes - Décalage: 0 mm; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0; Se déplace avec les éléments voisins: no
Cotes - Surface: 0.791744 m2; Volume: 0.113479 m3
Données d'identification - Identifiant: 25
Phase de construction - Phase de création: Nouvelle construction
Autre(Type) - Catégorie: Appareils sanitaires; Nom de la famille: BWT_Permaq Compact HQ
Cotes(Type) - BWT_Hauteur: 740 mm; BWT_Largeur: 350.012 mm; BWT_Profondeur: 530.098 mm
Données d'identification(Type) - Description: Osmoseur; Fabricant: BWT_FRANCE; Modèle: Permaq Compact 60HQ; Nom du type: Permaq Compact 60HQ; URL: http:\\www.bwt.fr
Données(Type) - BWT_CODE: P0004925; BWT_Consommation électrique normale: 1500 W; BWT_Débit perméat 10°C: 0.0000443333 m3/s; BWT_DN de raccordement: 12 mm; BWT_Masse en service (Vide): 50; BWT_Pression max eau alimentation: 600000 Pa; BWT_Pression min eau alimentation: 300000 Pa; BWT_Température maxi eau: 25 kg/K/s3; BWT_Température max local: 35 kg/K/s3; BWT_Température mini eau: 5 kg/K/s3; BWT_Température min local: 5 kg/K/s3; BWT_Tension électrique: 230 V; BWT_Volume réservoir perméat: 0.037 m3
Matériaux et finitions(Type) - Matériau 1: BWT_Métal; Matériau 2: BWT_Plastique noire; Matériau 3: BWT_Ecran; Matériau 4: BWT_Plastique gris
