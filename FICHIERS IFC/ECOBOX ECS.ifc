Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2017-03-22T16:03:52
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.5.0.0 - Interface alternative d'export 16.5.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 22 16:03:52 2017 * Host: LTBATREI25067 * Database: C:\Users\Blond\AppData\Local\Temp\{C6765001-39EB-4DCF-8BB9-685945A4015C}\ifc * Database version: 5507 * Database creation date: Wed Mar 22 16:03:51 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 22 16:03:51 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 22 16:03:51 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: BWT 3eme Serie

# IfcSite, Default
RefLatitude: 48, 51, 23, 807373; RefLongitude: 2, 21, 7, 999076; RefElevation: 0 mm
Autre - Catégorie: Informations sur le projet; Nom du client: BWT; Nom du projet: BWT 3eme Serie; Numéro de projet: 0001

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Nom du client: BWT; Nom du projet: BWT 3eme Serie; Numéro de projet: 0001

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Plein; Symbole: Marqueur de niveau - Cercle: Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Pointe 8 mm
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Autre - Catégorie: Niveaux; Famille: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; ID du type: Niveau: Pointe 8 mm; Type: Niveau: Pointe 8 mm
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 0; Structure: no

# IfcFlowTerminal: ECOBOX ECS, BWT_ECOBOX ECS:ECOBOX ECS:787749
In: Niveau 0
Material: BWT_Plastique blanc, Stratifié, bleu marine, BWT_Acier, BWT_Ecran, Plastique, noir opaque, BWT_Cuivre, Plastique, blanc opaque, BWT_Métal laqué noir
Pset_ManufacturerTypeInformation - Manufacturer: BWT_FRANCE
Pset_DistributionFlowElementCommon - Reference: ECOBOX ECS
Autre - Catégorie: Appareils sanitaires; Famille: BWT_ECOBOX ECS: ECOBOX ECS; Famille et type: BWT_ECOBOX ECS: ECOBOX ECS; ID du type: BWT_ECOBOX ECS: ECOBOX ECS; Type: BWT_ECOBOX ECS: ECOBOX ECS
Contraintes - Décalage: 1000 mm; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0
Cotes - Surface: 0.456655 m2; Volume: 0.00354145 m3
Données d'identification - Identifiant: 50
Génie climatique - Classification du système: Non défini
Phase de construction - Phase de création: Nouvelle construction
Autre(Type) - Catégorie: Appareils sanitaires; Nom de la famille: BWT_ECOBOX ECS
Cotes(Type) - BWT_Hauteur: 399.999 mm; BWT_Largeur: 610.933 mm; BWT_Profondeur: 145.962 mm
Données d'identification(Type) - Description: Kit ECS; Fabricant: BWT_FRANCE; Modèle: ECOBOX ECS; Nom du type: ECOBOX ECS; URL: http:\\www.bwt.fr
Données(Type) - BWT_CODE: PK0012270; BWT_Consommation électrique normale: 30 W; BWT_Débit minimal de fonctionnement: 0.00000833333 m3/s; BWT_DN de raccordement: 15 mm; BWT_Masse en service (Vide): 7.6; BWT_Plage de mesure 0mg/l < C < 10mg/l: 10; BWT_Pression de fonctionnement: 1-6 bar; BWT_Température maxi eau: 70 kg/K/s3; BWT_Température max local: 35 kg/K/s3; BWT_Température mini eau: 1 kg/K/s3; BWT_Température min local: 1 kg/K/s3; BWT_Tension électrique: 230 V; BWT_Type de raccordement: PVC-glue
Matériaux et finitions(Type) - Matériau 1: BWT_Métal laqué noir; Matériau 2: BWT_Acier; Matériau 3: BWT_Cuivre

# IfcFlowTerminal: Standard (2)
In: Niveau 0
Pset_DistributionFlowElementCommon - Reference: Standard
Autre - Catégorie: Appareils sanitaires
Contraintes - Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Génie climatique - Classification du système: Non défini
Phase de construction - Phase de création: Nouvelle construction
Autre(Type) - Catégorie: Appareils sanitaires
Données d'identification(Type) - Nom du type: Standard
Name | Material | Manufacturer = Fabricant | Famille = Famille et type = ID du type = Type | Décalage (mm) | Surface (m2) | Volume (m3) | Identifiant | Nom de la famille | Description | Matériau 1 | Matériau 2
Circulateur:Standard:787750 | Plastique, blanc opaque, Plastique, noir opaque, BWT_Cuivre, Aluminium, anodisé rouge | Grundfos | Circulateur: Standard | 53.9788 | 0.0404024 | 0.000707934 | 51 | Circulateur | Circulateur générique | Plastique, noir opaque | BWT_Cuivre | Données d'identification(Type) - URL: http:\\www.bwt.fr; Matériaux et finitions(Type) - Matériau 3: Aluminium, anodisé rouge; Matériau 4: Plastique, blanc opaque
Vanne Girpi:Standard:787751 | Aluminium, anodisé rouge, BWT_Métal laqué noir | GIRPI | Vanne Girpi: Standard | 54.5509 | 0.0117763 | 0.00014952 | 52 | Vanne Girpi | Vanne | BWT_Métal laqué noir | Aluminium, anodisé rouge
