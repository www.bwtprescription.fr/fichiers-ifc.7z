Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2017-03-22T13:58:59
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.5.0.0 - Interface alternative d'export 16.5.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 22 13:58:59 2017 * Host: LTBATREI25067 * Database: C:\Users\Blond\AppData\Local\Temp\{4C0DF4F7-A15D-415C-B97B-B364BBCE038E}\ifc * Database version: 5507 * Database creation date: Wed Mar 22 13:58:58 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 22 13:58:59 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 22 13:58:59 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: C:\Users\Blond\Desktop\Export IFC\Adouccisseur\FR\7150 SC.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Autre - Catégorie: Informations sur le projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Autre - Catégorie: Niveaux; Famille: Niveau: Niveau 1; Famille et type: Niveau: Niveau 1; ID du type: Niveau: Niveau 1; Type: Niveau: Niveau 1
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet
Données d'identification(Type) - Nom du type: Niveau 1
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Plein; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes

# IfcBuildingElementProxy: 800 x 720 mm, BWT_Bac à sel type 1:800 x 720 mm:2313
In: Niveau 1
Type - Material: Plastique PPS
Type - Autre(Type) - Catégorie: Modèles génériques; Nom de la famille: BWT_Bac à sel type 1
Type - Cotes(Type) - Diamètre: 720 mm; Hauteur: 800 mm
Type - Données d'identification(Type) - Description: Bac à sel; Fabricant: BWT; Nom du type: 800 x 720 mm; URL: http:\\www.bwt.fr
Pset_BuildingElementProxyCommon - Reference: 800 x 720 mm
Pset_ManufacturerTypeInformation - Manufacturer: BWT
Autre - Catégorie: Modèles génériques; Famille: BWT_Bac à sel type 1: 800 x 720 mm; Famille et type: BWT_Bac à sel type 1: 800 x 720 mm; ID du type: BWT_Bac à sel type 1: 800 x 720 mm; Type: BWT_Bac à sel type 1: 800 x 720 mm
Contraintes - Décalage: 0 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1; Se déplace avec les éléments voisins: no
Cotes - Surface: 1.22714 m2; Volume: 0.300441 m3
Phase de construction - Phase de création: Nouvelle construction

# IfcDistributionPort (16)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
2 x InPort_2312
OutPort_2316
OutPort_2314
InPort_2314
2 x OutPort_2325
InPort_2316
2 x OutPort_2323
2 x InPort_2322
InPort_2322 | Group: Eau froide sanitaire 2
OutPort_2329 | Group: Eau froide sanitaire 2
InPort_2322 | Group: Eau froide sanitaire 1
OutPort_2327 | Group: Eau froide sanitaire 1

# IfcFlowController: BWT_Simply-connect Coudée, BWT_Simply-connect Coudée:BWT_Simply-connect Coudée:2322
In: Niveau 1
Type - Material: INOX, Laiton, Acier, Par défaut
Type - Autre(Type) - Catégorie: Accessoire de canalisation; Nom de la famille: BWT_Simply-connect Coudée
Type - Données d'identification(Type) - Fabricant: BWT; Modèle: Simply connect; Nom du type: BWT_Simply-connect Coudée
Type - Données(Type) - BWT_DN de raccordement: 50 mm
Pset_ManufacturerTypeInformation - Manufacturer: BWT
Pset_DistributionFlowElementCommon - Reference: BWT_Simply-connect Coudée
Autre - Catégorie: Accessoire de canalisation; Famille: BWT_Simply-connect Coudée: BWT_Simply-connect Coudée; Famille et type: BWT_Simply-connect Coudée: BWT_Simply-connect Coudée; ID du type: BWT_Simply-connect Coudée: BWT_Simply-connect Coudée; Type: BWT_Simply-connect Coudée: BWT_Simply-connect Coudée
Contraintes - Niveau: Niveau: Niveau 1; Décalage: 2100 mm; Hôte: Niveau : Niveau 1
Cotes - Surface: 0.142759 m2; Taille: 50 mmø-50 mmø-50 mmø-50 mmø; Taille maximale: 50 mm; Taille minimale: 50 mm; Volume: 0.00182495 m3
Données d'identification - Identifiant: 197
Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau froide sanitaire 1,Eau froide sanitaire 2; Type de système: Système de canalisation: Eau froide sanitaire
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 50 mmø-50 mmø-50 mmø-50 mmø
Phase de construction - Phase de création: Nouvelle construction
Group: Eau froide sanitaire 2; Eau froide sanitaire 1

# IfcFlowSegment: Canalisation souple arrondie:Souple - Circulaire (2)
In: Niveau 1
Autre - Catégorie: Canalisation souple; Famille: Canalisation souple arrondie: Souple - Circulaire; Famille et type: Canalisation souple arrondie: Souple - Circulaire; ID du type: Canalisation souple arrondie: Souple - Circulaire; Type: Canalisation souple arrondie: Souple - Circulaire; sets with these values: 2
Contraintes - Niveau de référence: Niveau: Niveau 1; sets with these values: 2
Cotes - Diamètre extérieur: 50 mm; Diamètre intérieur: 50 mm; sets with these values: 2
Données d'identification - sets with these values: 2
Génie climatique - Classification du système: Non défini; Diamètre: 50 mm; sets with these values: 2
Génie climatique - Ecoulement - Etat du flux: Laminaire; Facteur de frottement: 0; Frottement: 0; Nombre de Reynolds: 0; Unités du dispositif: 0; Flux: 0 m3/s; Flux supplémentaire: 0 m3/s; Perte de charge: 0 Pa; Rugosité relative: 0.0009144; Vitesse: 0 m/s; sets with these values: 2
Graphismes - Modèle de gaine flexible: A voie unique; sets with these values: 2
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 50 mmø; sets with these values: 2
Phase de construction - Phase de création: Nouvelle construction; sets with these values: 2
Pset_DistributionFlowElementCommon - Reference: Souple - Circulaire
Autre(Type) - Catégorie: Canalisation souple; Nom de la famille: Canalisation souple arrondie
Données d'identification(Type) - Nom du type: Souple - Circulaire
Génie climatique(Type) - Rugosité: 0.04572 mm
Raccords(Type) - Té: Té - Générique: Standard; Transition: Transformation - Générique: Standard; Type de jonction préférée: Té; Union: Manchon - Générique: Standard
Name (Canalisation souple arrondie:Souple - Circulaire:...) | Décalage de départ (mm) | Longueur (mm) | Identifiant | Coupe
2323 | 1756.2 | 536.821 | 36 | 2
2325 | 1757.1 | 537.849 | 37 | 1

# IfcFlowSegment: Canalisation:Standard (4)
In: Niveau 1
Autre - Catégorie: Canalisation; Famille: Canalisation: Standard; Famille et type: Canalisation: Standard; ID du type: Canalisation: Standard; Type: Canalisation: Standard; sets with these values: 2
Contraintes - Inclinaison: 0; Justification horizontale: Centre; Justification verticale: Milieu; Niveau de référence: Niveau: Niveau 1
Cotes - Diamètre extérieur: 60.325 mm; Diamètre intérieur: 52.5018 mm; Taille: 50 mmø; sets with these values: 2
Données d'identification - sets with these values: 2
Génie climatique - Diamètre: 50 mm; Matériau: Acier, carbone; Nomenclature/type: Types de nomenclatures de canalisations: Nomenclature 40; Rugosité: 0.04572 mm; Segment de canalisation: Acier au carbone - Série 40; Type de connexion: Générique
Génie climatique - Ecoulement - Etat du flux: Laminaire; Facteur de frottement: 0; Flux: 0 m3/s; Flux supplémentaire: 0 m3/s; Frottement: 0; Nombre de Reynolds: 0; Perte de charge: 0 Pa; Rugosité relative: 0.000870827; Unités du dispositif: 0; Vitesse: 0 m/s
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 50 mmø; sets with these values: 2
Phase de construction - Phase de création: Nouvelle construction; sets with these values: 2
Pset_DistributionFlowElementCommon - Reference: Standard
Autre(Type) - Catégorie: Canalisation; Nom de la famille: Canalisation
Données d'identification(Type) - Nom du type: Standard
Name (Canalisation:Standard:...) | Décalage de départ (mm) = Décaler (mm) | Décalage extrémité (mm) | Longueur (mm) | Identifiant | Classification du système | Coupe | Inverser l'élévation (mm) | Surface (m2) | Contraintes, sets with these values = Génie climatique - Ecoulement, sets with these values
2314 | 1757.13 | 1757.1 | 3.75011 | 276 | Non défini | 1 | 1730.85 | 0.000589066
2316 | 1756.2 | 1756.2 | 3.75 | 277 | Non défini | 2 | 1729.95 | 0.000589048 | 2
2327 | 2100 | 2100 | 200 | 284 | Eau froide sanitaire | 2 | 2073.75 | 0.0314159 | 2 | Génie climatique - Type de système: Système de canalisation: Eau froide sanitaire; Nom du système: Eau froide sanitaire 1; sets with these values: 2; Group: Eau froide sanitaire 1
2329 | 2100 | 2100 | 200 | 285 | Eau froide sanitaire | 2 | 2073.75 | 0.0314159 | 2 | Génie climatique - Type de système: Système de canalisation: Eau froide sanitaire; Nom du système: Eau froide sanitaire 2; sets with these values: 2; Group: Eau froide sanitaire 2

# IfcFlowTerminal: 7150SC, BWT_7000SC:7150SC:2312
In: Niveau 1
Material: Plastique, noir opaque, Plastique, blanc opaque, Stratifié, bleu marine, Plastique ABS, UHMW, noir, INOX
Pset_ManufacturerTypeInformation - Manufacturer: BWT
Pset_DistributionFlowElementCommon - Reference: 7150SC
Autre - Catégorie: Appareils sanitaires; Famille: BWT_7000SC: 7150SC; Famille et type: BWT_7000SC: 7150SC; ID du type: BWT_7000SC: 7150SC; Type: BWT_7000SC: 7150SC
Contraintes - Décalage: 0.0410041 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1
Cotes - Surface: 2.27667 m2; Volume: 0.300083 m3
Données - BWT_URL_Produit: http://www.bwt.fr/fr/Documentations/Eau_dconsommation_Humaine/Adoucissement/Pages/default.aspx
Données d'identification - Identifiant: 10
Génie climatique - Classification du système: Eau froide sanitaire
Phase de construction - Phase de création: Nouvelle construction
Autre(Type) - Catégorie: Appareils sanitaires; BWT_Hauteur de raccordment: 1756 mm; BWT_Hauteur Ecran de contrôle: 215 mm; BWT_Hauteur socle: 150 mm; Nom de la famille: BWT_7000SC
Cotes(Type) - BWT_Diamètre: 460 mm; BWT_Hauteur: 1920 mm; BWT_Hauteur bac à sel: 800 mm; BWT_Largeur bac à sel: 720 mm; BWT_Longueur bac à sel: 0 mm
Données d'identification(Type) - Description: Adoucisseur; Fabricant: BWT; Image du type: Image raster: BWT_7000SC.jpg; Modèle: BWT 7150 SC; Nom du type: 7150SC; URL: http:\\www.bwt.fr
Données(Type) - BWT_ACS: yes; BWT_Capacité bac à sel: 200; BWT_Capacité d'échange (°f.m3): 825; BWT_CODE: BK07150SC40; BWT_Consommation électrique en regénération: 50 W; BWT_Consommation électrique normale: 10 W; BWT_Débit à TH0° F: 0.0931915 m3/s; BWT_Débit eau de rejet: 0.0156954 m3/s; BWT_DN de raccordement: 50 mm; BWT_Masse en service: 850; BWT_Origine France Garantie: yes; BWT_Pression maximum: 700000 Pa; BWT_Pression minimum: 150000 Pa; BWT_Température maxi eau: 35 kg/K/s3; BWT_Température max local: 40 kg/K/s3; BWT_Température mini eau: 5 kg/K/s3; BWT_Température min local: 5 kg/K/s3; BWT_Tension électrique: 230 V; BWT_Volume de résine: 0.15 m3
Visibilité(Type) - Bac à sel Carré: no; Bac à sel Type 1: no; Bac à sel Type 2: yes

# IfcSystem: Eau froide sanitaire (2)
Autre - Catégorie: Système de canalisation; Famille: Système de canalisation: Eau froide sanitaire; Famille et type: Système de canalisation: Eau froide sanitaire; ID du type: Système de canalisation: Eau froide sanitaire; Type: Système de canalisation: Eau froide sanitaire
Génie climatique - Unités du dispositif: 0; Nombre d'éléments: 0; Volume: 0.000702903 m3
Génie climatique - Ecoulement - Flux: 0 m3/s
Name | Nom du système
Eau froide sanitaire 2 | Eau froide sanitaire 2
Eau froide sanitaire 1 | Eau froide sanitaire 1
