Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2017-03-22T16:05:18
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.5.0.0 - Interface alternative d'export 16.5.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 22 16:05:18 2017 * Host: LTBATREI25067 * Database: C:\Users\Blond\AppData\Local\Temp\{1AB468B3-7259-41B6-B2B7-3B9D16B6B1EF}\ifc * Database version: 5507 * Database creation date: Wed Mar 22 16:05:18 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 22 16:05:18 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 22 16:05:18 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: BWT 3eme Serie

# IfcSite, Default
RefLatitude: 48, 51, 23, 807373; RefLongitude: 2, 21, 7, 999076; RefElevation: 0 mm
Autre - Catégorie: Informations sur le projet; Nom du client: BWT; Nom du projet: BWT 3eme Serie; Numéro de projet: 0001

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Nom du client: BWT; Nom du projet: BWT 3eme Serie; Numéro de projet: 0001

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Plein; Symbole: Marqueur de niveau - Cercle: Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Pointe 8 mm
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Autre - Catégorie: Niveaux; Famille: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; ID du type: Niveau: Pointe 8 mm; Type: Niveau: Pointe 8 mm
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 0; Structure: no

# IfcBuildingElementProxy: Coffret d'alarme, Coffet d'alarme UV EU:Coffret d'alarme:750170
In: Niveau 0
Type - Material: Stratifié, bleu marine, BWT_Plastique blanc
Type - Autre(Type) - Catégorie: Equipement électrique; Nom de la famille: Coffet d'alarme UV EU
Type - Cotes(Type) - BWT_Hauteur: 185 mm; BWT_Largeur: 181 mm; BWT_Profondeur: 172 mm
Type - Données d'identification(Type) - Description: Coffret d'alarme; Fabricant: BWT_FRANCE; Nom du type: Coffret d'alarme; URL: http:\\www.bwt.fr
Type - Matériaux et finitions(Type) - Matériau 1: BWT_Plastique gris; Matériau 2: Stratifié, bleu marine; Matériau 3: BWT_Ecran; Matériau 4: Plastique, noir opaque
Pset_BuildingElementProxyCommon - Reference: Coffret d'alarme
Pset_ManufacturerTypeInformation - Manufacturer: BWT_FRANCE
Autre - Catégorie: Equipement électrique; Famille: Coffet d'alarme UV EU: Coffret d'alarme; Famille et type: Coffet d'alarme UV EU: Coffret d'alarme; ID du type: Coffet d'alarme UV EU: Coffret d'alarme; Type: Coffet d'alarme UV EU: Coffret d'alarme
Contraintes - Niveau: Niveau: Niveau 0; Décalage: 1000 mm; Hôte: Niveau : Niveau 0
Cotes - Surface: 0.112232 m2; Volume: 0.00675009 m3
Données d'identification - Identifiant: 22
Phase de construction - Phase de création: Nouvelle construction

# IfcBuildingElementProxy: Coffret de commande, Coffret de commande UV EU:Coffret de commande:748819
In: Niveau 0
Type - Material: Stratifié, bleu marine, BWT_Ecran, BWT_Plastique blanc
Type - Autre(Type) - Catégorie: Equipement électrique; Nom de la famille: Coffret de commande UV EU
Type - Cotes(Type) - BWT_Hauteur: 185 mm; BWT_Largeur: 181 mm; BWT_Profondeur: 172 mm
Type - Données d'identification(Type) - Description: Coffret de commande; Fabricant: BWT_FRANCE; Nom du type: Coffret de commande; URL: http:\\www.bwt.fr
Type - Matériaux et finitions(Type) - Matériau 1: BWT_Plastique gris; Matériau 2: Stratifié, bleu marine; Matériau 3: BWT_Ecran; Matériau 4: Plastique, noir opaque
Pset_BuildingElementProxyCommon - Reference: Coffret de commande
Pset_ManufacturerTypeInformation - Manufacturer: BWT_FRANCE
Autre - Catégorie: Equipement électrique; Famille: Coffret de commande UV EU: Coffret de commande; Famille et type: Coffret de commande UV EU: Coffret de commande; ID du type: Coffret de commande UV EU: Coffret de commande; Type: Coffret de commande UV EU: Coffret de commande
Contraintes - Niveau: Niveau: Niveau 0; Décalage: 1000 mm; Hôte: Niveau : Niveau 0
Cotes - Surface: 0.135247 m2; Volume: 0.00543948 m3
Données d'identification - Identifiant: 19
Electricité - Charges - Charge apparente - Phase A: 0 W; Charge apparente - Phase B: 0 W; Charge apparente - Phase C: 0 W; Charge totale connectée: 0 W; Demande de charge totale estimée: 0 W; Facteur de charge totale: 1
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowTerminal: UV EU 11 DN50, BWT_UV EU11:UV EU 11 DN50:740742
In: Niveau 0
Material: BWT_Acier galvanisé, Stratifié, bleu marine
Pset_ManufacturerTypeInformation - Manufacturer: BWT_FRANCE
Pset_DistributionFlowElementCommon - Reference: UV EU 11 DN50
Autre - Catégorie: Appareils sanitaires; Famille: BWT_UV EU11: UV EU 11 DN50; Famille et type: BWT_UV EU11: UV EU 11 DN50; ID du type: BWT_UV EU11: UV EU 11 DN50; Type: BWT_UV EU11: UV EU 11 DN50
Contraintes - Décalage: 0 mm; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0
Cotes - Surface: 0.253254 m2; Volume: 0.0129538 m3
Données d'identification - Identifiant: 14
Génie climatique - Classification du système: Non défini
Phase de construction - Phase de création: Nouvelle construction
Autre(Type) - Catégorie: Appareils sanitaires; Nom de la famille: BWT_UV EU11
Cotes(Type) - A: 113.596 mm; B: 128 mm; BWT_Diamètre: 113.596 mm; BWT_Hauteur: 1310 mm; D: 1196 mm; E: 1310 mm
Données d'identification(Type) - Description: Equipement de désinfection; Fabricant: BWT_FRANCE; Modèle: UV EU 11 DN50; Nom du type: UV EU 11 DN50; URL: http:\\www.bwt.fr
Données(Type) - BWT_CODE: P0002208; BWT_Consommation électrique normale: 500 W; BWT_DN de raccordement: 50 mm; BWT_Durée de vie attendue générateur: 10000 14000h; BWT_Nombre de générateur: 3; BWT_Pression de fonctionnement: 10; BWT_Puissance générateur par unité: 100 W; BWT_Puissance UVC générateur neuf: 34 W; BWT_Température maxi eau: 30 kg/K/s3; BWT_Température max local: 40 kg/K/s3; BWT_Température mini eau: 5 kg/K/s3; BWT_Température min local: 5 kg/K/s3; BWT_Tension électrique: 230 V; BWT_Type de raccordement: Fileté
Matériaux et finitions(Type) - Matériau 1: BWT_Acier galvanisé; Matériau 2: Stratifié, bleu marine
