Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2017-03-22T13:54:51
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.5.0.0 - Interface alternative d'export 16.5.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 22 13:54:51 2017 * Host: LTBATREI25067 * Database: C:\Users\Blond\AppData\Local\Temp\{8F3119F9-499E-43FF-8711-54AF87C0D926}\ifc * Database version: 5507 * Database creation date: Wed Mar 22 13:54:51 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 22 13:54:51 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 22 13:54:51 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: C:\Users\Blond\Desktop\Export IFC\Adouccisseur\FR\EC17.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Autre - Catégorie: Informations sur le projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Plein; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Niveau 1
Autre - Catégorie: Niveaux; Famille: Niveau: Niveau 1; Famille et type: Niveau: Niveau 1; ID du type: Niveau: Niveau 1; Type: Niveau: Niveau 1
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet

# IfcBuildingElementProxy: 680 x 480 mm, BWT_Bac à sel type 1:680 x 480 mm:2313
In: Niveau 1
Type - Material: Plastique PPS
Type - Autre(Type) - Catégorie: Modèles génériques; Nom de la famille: BWT_Bac à sel type 1
Type - Cotes(Type) - Diamètre: 480 mm; Hauteur: 680 mm
Type - Données d'identification(Type) - Description: Bac à sel; Fabricant: BWT; Nom du type: 680 x 480 mm; URL: http:\\www.bwt.fr
Pset_BuildingElementProxyCommon - Reference: 680 x 480 mm
Pset_ManufacturerTypeInformation - Manufacturer: BWT
Autre - Catégorie: Modèles génériques; Famille: BWT_Bac à sel type 1: 680 x 480 mm; Famille et type: BWT_Bac à sel type 1: 680 x 480 mm; ID du type: BWT_Bac à sel type 1: 680 x 480 mm; Type: BWT_Bac à sel type 1: 680 x 480 mm
Contraintes - Décalage: 0 mm; Niveau: Niveau: Niveau 1; Hôte: Niveau : Niveau 1; Se déplace avec les éléments voisins: no
Cotes - Surface: 0.632242 m2; Volume: 0.109115 m3
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowTerminal: EC 17, BWT_EC:EC 17:2312
In: Niveau 1
Material: Acier, moulé, Plastique, blanc opaque, Cuivre, Plastique, noir opaque, Poignée rouge Acier, Metal bleu
Pset_ManufacturerTypeInformation - Manufacturer: BWT_FRANCE
Pset_DistributionFlowElementCommon - Reference: EC 17
Autre - Catégorie: Appareils sanitaires; Famille: BWT_EC: EC 17; Famille et type: BWT_EC: EC 17; ID du type: BWT_EC: EC 17; Type: BWT_EC: EC 17
Contraintes - Décalage: 0 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1
Cotes - Surface: 0.480565 m2; Volume: 0.025001 m3
Données - BWT_URL_Produit: http://www.bwt.fr/fr/Documentations/Eau_dconsommation_Humaine/Adoucissement/Pages/default.aspx
Données d'identification - Identifiant: 17
Génie climatique - Classification du système: Eau froide sanitaire
Phase de construction - Phase de création: Nouvelle construction
Autre(Type) - Catégorie: Appareils sanitaires; BWT_Ecart Logo: 100 mm; BWT_Hauteur cylindre: 480 mm; BWT_Hauteur de raccordment: 523 mm; BWT_Hauteur Logo: 230 mm; BWT-Hauteur socle: 146 mm; BWT-Hauteur socle ecran de contrôle: 38.4 mm; Nom de la famille: BWT_EC
Cotes(Type) - BWT_Diamètre: 255 mm; BWT_Hauteur: 680 mm; BWT_Hauteur bac à sel: 680 mm; BWT_Hauteur bouteille: 492 mm; BWT_Largeur bac à sel: 480 mm
Données d'identification(Type) - Description: Adoucisseur; Fabricant: BWT_FRANCE; Modèle: EC 17; Nom du type: EC 17; URL: http:\\www.bwt.fr
Données(Type) - BWT_ACS: no; BWT_Capacité bac à sel: 100; BWT_Capacité d'échange (°f.m3): 100; BWT_CODE: PK0001571; BWT_Débit à TH0° F: 0.0245241 m3/s; BWT_DN de raccordement: 25 mm; BWT_Masse en service: 150; BWT_Origine France Garantie: no; BWT_Pression maximum: 860000 Pa; BWT_Pression minimum: 200000 Pa; BWT_Température maxi eau: 65 kg/K/s3; BWT_Température max local: 40 kg/K/s3; BWT_Température mini eau: 5 kg/K/s3; BWT_Température min local: 5 kg/K/s3; BWT_Tension électrique: 230 V; BWT_Volume de résine: 0.017 m3
Matériaux et finitions(Type) - Matériau 3: Plastique, blanc opaque
Visibilité(Type) - Bac à sel Type 1: yes; Bac à sel Type 2: no; Visilibité simply connect: no
