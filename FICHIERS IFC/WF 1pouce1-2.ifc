Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2017-03-22T11:53:58
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.5.0.0 - Interface alternative d'export 16.5.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 22 11:53:58 2017 * Host: LTBATREI25067 * Database: C:\Users\Blond\AppData\Local\Temp\{95C01FE0-DC99-4850-82D7-28FA01B4F84C}\ifc * Database version: 5507 * Database creation date: Wed Mar 22 11:53:57 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 22 11:53:57 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 22 11:53:57 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 52, 0, 117187; RefLongitude: 2, 19, 59, 880409; RefElevation: 0 mm
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Centre; Symbole: Marqueur de niveau - Cercle: Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Pointe 8 mm
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Autre - Catégorie: Niveaux; Famille: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; ID du type: Niveau: Pointe 8 mm; Type: Niveau: Pointe 8 mm
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no

# IfcFlowController: WF 1" 1/2, BWT_Filtre WF:WF 1" 1/2:176325
In: Niveau 1
Type - Material: Laiton, Aluminium, anodisé rouge, Verre opaque
Type - Autre(Type) - Catégorie: Accessoire de canalisation; Envergure base: 37 mm; Nom de la famille: BWT_Filtre WF
Type - Cotes(Type) - BWT_Hauteur: 290 mm; BWT_Profondeur: 254 mm; BWT_Rayon: 20 mm
Type - Données d'identification(Type) - Description: Filtre; Fabricant: BWT; Modèle: WF; Nom du type: WF 1" 1/2; Numéro OmniClass: 23.60.10.17; Titre OmniClass: Flow Meters; URL: http:\\www.bwt.fr
Type - Données(Type) - BWT_CODE: P0003199; BWT_Débit eau de rejet: 0.14224 m3/s; BWT_DN de raccordement: 40 mm; BWT_Element filtrant: tamis; BWT_Masse en service: 4.8; BWT_Matériau: Laiton; BWT_Pression maximum: 1000000 Pa; BWT_Seuil de filtration: 90/110 µm; BWT_Température maxi eau: 30 kg/K/s3; BWT_Température max local: 40 kg/K/s3; BWT_Température mini eau: 5 kg/K/s3; BWT_Température min local: 5 kg/K/s3; BWT_Type de raccordement: fileté
Type - Matériaux et finitions(Type) - Matériau 1: Laiton; Matériau 2: Verre opaque; Matériau 3: Aluminium, anodisé rouge
Pset_ManufacturerTypeInformation - Manufacturer: BWT
Pset_DistributionFlowElementCommon - Reference: WF 1" 1/2
Autre - Catégorie: Accessoire de canalisation; Famille: BWT_Filtre WF: WF 1" 1/2; Famille et type: BWT_Filtre WF: WF 1" 1/2; ID du type: BWT_Filtre WF: WF 1" 1/2; Type: BWT_Filtre WF: WF 1" 1/2
Contraintes - Décalage: 0 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1
Cotes - Surface: 0.0320852 m2; Taille: 50 mmø-40 mmø; Taille maximale: 50 mm; Taille minimale: 40 mm; Volume: 0.000795152 m3
Données d'identification - Identifiant: 18
Génie climatique - Classification du système: Non défini
Graphismes - Utiliser l'échelle d'annotations: no
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 50 mmø-40 mmø
Phase de construction - Phase de création: Phase 1
