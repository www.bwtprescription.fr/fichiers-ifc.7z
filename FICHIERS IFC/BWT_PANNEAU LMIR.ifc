Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2017-06-30T11:37:38
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.5.0.0 - Interface alternative d'export 16.5.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jun 30 11:37:38 2017 * Host: LTBATREI25067 * Database: C:\Users\Blond\AppData\Local\Temp\{ABDF010A-5665-422C-87FC-78B92314C39A}\ifc * Database version: 5507 * Database creation date: Fri Jun 30 11:37:37 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jun 30 11:37:38 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jun 30 11:37:38 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: BWT 4ème serie; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 52, 0, 117187; RefLongitude: 2, 19, 59, 880409; RefElevation: 0 mm
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: BWT 4ème serie; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: BWT 4ème serie; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Centre; Symbole: Marqueur de niveau - Cercle: Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Pointe 8 mm
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Autre - Catégorie: Niveaux; Famille: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; ID du type: Niveau: Pointe 8 mm; Type: Niveau: Pointe 8 mm
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no

# IfcFlowController: Compteur, BWT_Compteur:Compteur:201053
In: Niveau 1
Type - Material: BWT_Cuivre, Aluminium, anodisé rouge, UHMW, noir, BWT_Plastique blanc, BWT_Acier galvanisé
Type - Autre(Type) - Catégorie: Accessoire de canalisation; Nom de la famille: BWT_Compteur
Type - Contraintes(Type) - Elévation par défaut: 1219.2 mm
Type - Données d'identification(Type) - Description: Compteur; Nom du type: Compteur
Type - Matériaux et finitions(Type) - Matériau 1: BWT_Acier galvanisé; Matériau 2: BWT_Plastique blanc; Matériau 3: BWT_Cuivre
Pset_DistributionFlowElementCommon - Reference: Compteur
Autre - Catégorie: Accessoire de canalisation; Famille: BWT_Compteur: Compteur; Famille et type: BWT_Compteur: Compteur; ID du type: BWT_Compteur: Compteur; Type: BWT_Compteur: Compteur
Contraintes - Niveau: Niveau: Niveau 1; Décalage: 370 mm; Hôte: Niveau : Niveau 1; Se déplace avec les éléments voisins: no
Cotes - Surface: 0.0229838 m2; Volume: 0.18409 dm3
Données d'identification - Identifiant: 5
Isolation - Epaisseur d'isolation: 0 mm
Phase de construction - Phase de création: Phase 1

# IfcFlowController: Standard (3)
In: Niveau 1
Type - Material: BWT_Plastique bleu, BWT_Métal laqué noir
Type - Autre(Type) - Catégorie: Accessoire de canalisation; Nom de la famille: BWT_Vanne PVC Pression
Type - Contraintes(Type) - Elévation par défaut: 1219.2 mm
Type - Données d'identification(Type) - Description: Vanne PVC Pression; Nom du type: Standard
Type - Matériaux et finitions(Type) - Matériau 1: BWT_Métal laqué noir; Matériau 2: BWT_Plastique bleu
Pset_DistributionFlowElementCommon - Reference: Standard
Autre - Catégorie: Accessoire de canalisation; Famille: BWT_Vanne PVC Pression: Standard; Famille et type: BWT_Vanne PVC Pression: Standard; ID du type: BWT_Vanne PVC Pression: Standard; Type: BWT_Vanne PVC Pression: Standard
Contraintes - Décalage: 85 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1
Cotes - Surface: 0.0118901 m2; Taille: 20 mmø-20 mmø; Taille maximale: 20 mm; Taille minimale: 20 mm; Volume: 0.146973 dm3
Génie climatique - Classification du système: Non défini
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 20 mmø-20 mmø
Phase de construction - Phase de création: Phase 1
Name (BWT_Vanne PVC Pression:Standard:...) | Identifiant
201050 | 2
201051 | 3
201052 | 4

# IfcFlowTerminal: Panneau LMIR, BWT_PANNEAU LMIR:Panneau LMIR:201049
In: Niveau 1
Material: BWT_Métal laqué noir, BWT_Plastique blanc, BWT_Bleu marine, BWT_Plastique noir, matière thermometre, BWT_Plastique jaune, BWT_Plastique bleu, BWT_Bleu marine gris
Pset_ManufacturerTypeInformation - Manufacturer: BWT_FRANCE
Pset_DistributionFlowElementCommon - Reference: Panneau LMIR
Autre - Catégorie: Appareils sanitaires; Famille: BWT_PANNEAU LMIR: Panneau LMIR; Famille et type: BWT_PANNEAU LMIR: Panneau LMIR; ID du type: BWT_PANNEAU LMIR: Panneau LMIR; Type: BWT_PANNEAU LMIR: Panneau LMIR
Contraintes - Décalage: 1000 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1
Cotes - Surface: 0.911305 m2; Volume: 14.3927 dm3
Données d'identification - Identifiant: 22
Génie climatique - Classification du système: Eau froide sanitaire
Phase de construction - Phase de création: Phase 1
Autre(Type) - Catégorie: Appareils sanitaires; Nom de la famille: BWT_PANNEAU LMIR
Cotes(Type) - BWT_Hauteur: 600 mm; BWT_Largeur: 850 mm; BWT_Profondeur: 150 mm
Données d'identification(Type) - Fabricant: BWT_FRANCE; Modèle: Panneau LMIR; Nom du type: Panneau LMIR; URL: http:\\www.bwt.fr
Données(Type) - BWT_CODE: P0962592; BWT_DN de raccordement: 15 mm; BWT_Tension électrique: 230 V
Matériaux et finitions(Type) - Matériau 1: BWT_Plastique blanc; Matériau 2: BWT_Plastique noir; Matériau 3: BWT_Bleu marine gris; Matériau 4: BWT_Plastique bleu; Matériau 5: BWT_Plastique jaune

# IfcFlowTerminal: Resistivimètre, BWT_Resistivimètre:Resistivimètre:201054
In: Niveau 1
Material: BWT_Plastique blanc, Stratifié, bleu marine, BWT_Acier, BWT_Ecran
Matériaux et finitions(Type) - Matériau 1: BWT_Plastique blanc; Matériau 2: Stratifié, bleu marine; Matériau 3: BWT_Ecran; Matériau 4: BWT_Acier
Pset_ManufacturerTypeInformation - Manufacturer: BWT_FRANCE
Pset_DistributionFlowElementCommon - Reference: Resistivimètre
Autre - Catégorie: Appareils sanitaires; Famille: BWT_Resistivimètre: Resistivimètre; Famille et type: BWT_Resistivimètre: Resistivimètre; ID du type: BWT_Resistivimètre: Resistivimètre; Type: BWT_Resistivimètre: Resistivimètre
Contraintes - Niveau: Niveau: Niveau 1; Se déplace avec les éléments voisins: no; Décalage: 155 mm; Hôte: Niveau : Niveau 1
Cotes - Surface: 0.100669 m2; Volume: 1.7104 dm3
Données d'identification - Identifiant: 23
Phase de construction - Phase de création: Phase 1
Autre(Type) - Catégorie: Appareils sanitaires; Nom de la famille: BWT_Resistivimètre
Cotes(Type) - BWT_depth: 188 mm; BWT_Height: 106 mm; BWT_width: 160 mm
Données d'identification(Type) - Fabricant: BWT_FRANCE; Modèle: PROBOX; Nom du type: Resistivimètre; URL: http:\\www.bwt.fr
