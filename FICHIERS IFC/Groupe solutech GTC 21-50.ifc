Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2017-03-30T13:47:04
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.5.0.0 - Interface alternative d'export 16.5.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Mar 30 13:47:04 2017 * Host: LTBATREI25067 * Database: C:\Users\Blond\AppData\Local\Temp\{6B878661-E6F0-4594-B975-A84D5AD8B6F8}\ifc * Database version: 5507 * Database creation date: Thu Mar 30 13:47:03 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Mar 30 13:47:03 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Mar 30 13:47:03 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: C:\Users\Blond\Desktop\Export IFC-Filtre-Groupe Solutech-BWT-170330\FR\Groupe solutech GTC 21-50.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Autre - Catégorie: Informations sur le projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Plein; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Niveau 1
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Autre - Catégorie: Niveaux; Famille: Niveau: Niveau 1; Famille et type: Niveau: Niveau 1; ID du type: Niveau: Niveau 1; Type: Niveau: Niveau 1
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no

# IfcBuildingElementProxy: Coffret électrique, BWT_Boitier Electrique Type 2:Coffret électrique:2323
In: Niveau 1
Type - Material: BWT_Plastique gris, BWT_Plastique blanc, BWT_Plastique rouge, BWT_Plastique vert
Type - Autre(Type) - Catégorie: Equipement électrique; Nom de la famille: BWT_Boitier Electrique Type 2
Type - Données d'identification(Type) - Description: Coffret électrique; Fabricant: BWT; Nom du type: Coffret électrique; URL: http:\\www.bwt.fr
Pset_BuildingElementProxyCommon - Reference: Coffret électrique
Pset_ManufacturerTypeInformation - Manufacturer: BWT
Autre - Catégorie: Equipement électrique; Famille: BWT_Boitier Electrique Type 2: Coffret électrique; Famille et type: BWT_Boitier Electrique Type 2: Coffret électrique; ID du type: BWT_Boitier Electrique Type 2: Coffret électrique; Type: BWT_Boitier Electrique Type 2: Coffret électrique
Contraintes - Niveau: Niveau: Niveau 1; Se déplace avec les éléments voisins: no; Décalage: 1000 mm; Hôte: Niveau : Niveau 1
Cotes - Surface: 0.145842 m2; Volume: 0.00962062 m3
Données d'identification - Identifiant: 5
Electricité - Charges - Charge apparente - Phase A: 0 W; Charge apparente - Phase B: 0 W; Charge apparente - Phase C: 0 W; Charge totale connectée: 0 W; Demande de charge totale estimée: 0 W; Facteur de charge totale: 1
Phase de construction - Phase de création: Nouvelle construction

# IfcBuildingElementProxy: TP 80-140/2, Grundfos 80-140:TP 80-140/2:2324
In: Niveau 1
Type - Material: Steel - Grundfos - Black
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Nom de la famille: Grundfos 80-140
Type - Cotes(Type) - Port to Port: 360 mm
Type - Données d'identification(Type) - Author: Grundfos; Copyright: © Grundfos; Date Created: August 17, 2016; Date Modified: August 17, 2016; Description: Grundfos vertical, close-coupled, single-stage, in-line, centrifugal volute pumps with standard motors and mechanical shaft seals; Equipment Abbreviation: PMP; Fabricant: Grundfos; Family Version: 1.0; Manufacturer Website: http://www.Grundfos.com; Model Disclaimer: For more information, contact Grundfos; Modèle: TP 80-180/2; Nom du type: TP 80-140/2; Numéro OmniClass: 23.27.17.00; OmniClass: 23.27.17.00; Product Documentation Link: http://product-selection.grundfos.com/catalogue.product%20families.tp.html; Revit Version: 2014; URL: http://product-selection.grundfos.com/; Watermarked By: Grundfos
Type - Electricité(Type) - Load Classification: Other; Number of Poles: 1; PowerFactor: 0.87; SupplyFrequency: 50 Hz; SupplyPhase: 3; SupplyVoltage: 220 V
Type - Génie climatique(Type) - Enclosure Rating: 55; Flow: 0.566997 m3/s; Head: 1765146 Pa; Maximum Motor Power Rating: 3; Maximum Operating Pressure: 1600000 Pa; Maximum Operating Temperature: 60 kg/K/s3
Type - Matériaux et finitions(Type) - Motor Material: Steel - Grundfos - Black; Pump Material: Steel - Grundfos - Black
Type - Propriétés du modèle(Type) - Efficiency Rating: 0.69; Gross Weight: 0.735496 kN; Manufacturer Ar. No.: 5700396973814; Net Weight: 0.657043 kN; ProductCode: TP 80-180/2; Product Number: USE TYPE CATALOG; Product Range: TP000
Pset_BuildingElementProxyCommon - Reference: TP 80-140/2
Pset_ManufacturerTypeInformation - Manufacturer: Grundfos
Autre - Catégorie: Equipement de génie climatique; Famille: Grundfos 80-140: TP 80-140/2; Famille et type: Grundfos 80-140: TP 80-140/2; ID du type: Grundfos 80-140: TP 80-140/2; Type: Grundfos 80-140: TP 80-140/2
Contraintes - Niveau: Niveau: Niveau 1; Décalage: 251.5 mm; Hôte: Niveau : Niveau 1
Cotes - Surface: 0.472208 m2; Volume: 0.0233016 m3
Données d'identification - Identifiant: 11; Part Description: Grundfos vertical, close-coupled, single-stage, in-line, centrifugal volute pumps with standard motors and mechanical shaft seals; Part Number: TP 80-180/2
Génie climatique - Classification du système: Eau froide sanitaire,Puissance
Graphismes - Annotative Symbol Native Radius: 3.175 mm; Has Concrete Pour: yes; Show Annotative Symbol: no; Show Masking Regions: yes
Phase de construction - Phase de création: Nouvelle construction

# IfcDistributionPort (16)
Description: Flow
Name | FlowDirection
3 x InPort_2312 | SOURCEANDSINK
OutPort_2325 | SOURCEANDSINK
OutPort_2320 | SOURCEANDSINK
2 x OutPort_2318 | SOURCEANDSINK
2 x InPort_2314 | SOURCEANDSINK
OutPort_2316 | SOURCEANDSINK
OutPort_2324 | SOURCEANDSINK
InPort_2317 | SOURCEANDSINK
InPort_2320 | SOURCEANDSINK
OutPort_2322 | SOURCEANDSINK
InPort_2324 | SINK
OutPort_2325 | SOURCE

# IfcFlowController: DN 80 (2)
In: Niveau 1
Type - Material: BWT_Bleu Métal, BWT_Plastique noir
Type - Autre(Type) - Catégorie: Accessoire de canalisation; Nom de la famille: Clapet Anti-Retour 4 fixations
Type - Données d'identification(Type) - Nom du type: DN 80; Numéro OmniClass: 23.60.10.17; Titre OmniClass: Flow Meters
Type - Données(Type) - BWT_DN de raccordement: 80 mm
Type - Matériaux et finitions(Type) - Matériau 1: BWT_Plastique noir; Matériau 2: BWT_Bleu Métal
Pset_DistributionFlowElementCommon - Reference: DN 80
Autre - Catégorie: Accessoire de canalisation; Famille: Clapet Anti-Retour 4 fixations: DN 80; Famille et type: Clapet Anti-Retour 4 fixations: DN 80; ID du type: Clapet Anti-Retour 4 fixations: DN 80; Type: Clapet Anti-Retour 4 fixations: DN 80
Contraintes - Niveau: Niveau: Niveau 1; Hôte: Niveau : Niveau 1
Cotes - Surface: 0.0799891 m2; Taille: 80 mmø-80 mmø; Taille maximale: 80 mm; Taille minimale: 80 mm; Volume: 0.00113468 m3
Génie climatique - Classification du système: Eau froide sanitaire
Graphismes - Utiliser l'échelle d'annotations: no
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 80 mmø-80 mmø
Phase de construction - Phase de création: Nouvelle construction
Name (Clapet Anti-Retour 4 fixations:DN 80:...) | Décalage (mm) | Angle manette (deg) | Identifiant
2316 | 251.5 | 90 | 83
2317 | 516.5 | 0 | 84

# IfcFlowController: Robinet de purge, Robinet de purge:Robinet de purge:2322
In: Niveau 1
Type - Material: BWT_Plastique rouge, BWT_Laiton
Type - Autre(Type) - Catégorie: Accessoire de canalisation; Nom de la famille: Robinet de purge
Type - Données d'identification(Type) - Description: Robinet de purge; Fabricant: BWT_FRANCE; Modèle: Robinet de Purge Groupe Solutech; Nom du type: Robinet de purge; URL: http:\\www.bwt.fr
Type - Données(Type) - BWT_DN de raccordement: 20 mm
Pset_ManufacturerTypeInformation - Manufacturer: BWT_FRANCE
Pset_DistributionFlowElementCommon - Reference: Robinet de purge
Autre - Catégorie: Accessoire de canalisation; Famille: Robinet de purge: Robinet de purge; Famille et type: Robinet de purge: Robinet de purge; ID du type: Robinet de purge: Robinet de purge; Type: Robinet de purge: Robinet de purge
Contraintes - Niveau: Niveau: Niveau 1; Décalage: 516.5 mm; Hôte: Niveau : Niveau 1
Cotes - Angle robinet: 90 deg; Surface: 0.00669471 m2; Taille: 20 mmø-20 mmø; Taille maximale: 20 mm; Taille minimale: 20 mm; Volume: 0.0000704413 m3
Données d'identification - Identifiant: 85
Génie climatique - Classification du système: Eau froide sanitaire
Graphismes - Utiliser l'échelle d'annotations: no
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 20 mmø-20 mmø
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowSegment: Canalisation:Par défaut (4)
In: Niveau 1
Autre - Catégorie: Canalisation; Famille: Canalisation: Par défaut; Famille et type: Canalisation: Par défaut; ID du type: Canalisation: Par défaut; Type: Canalisation: Par défaut; sets with these values: 2
Contraintes - Inclinaison: 0; Justification horizontale: Centre; Justification verticale: Milieu; Niveau de référence: Niveau: Niveau 1
Cotes - sets with these values: 2
Données d'identification - sets with these values: 2
Génie climatique - Classification du système: Non défini; Matériau: Acier au carbone; Nomenclature/type: Types de nomenclatures de canalisations: Nomenclature 40; Rugosité: 0.04572 mm; Segment de canalisation: Acier au carbone - Nomenclature 40; Type de connexion: Générique
Génie climatique - Ecoulement - Etat du flux: Laminaire; Facteur de frottement: 0; Flux: 0 m3/s; Flux supplémentaire: 0 m3/s; Frottement: 0; Nombre de Reynolds: 0; Perte de charge: 0 Pa; Unités du dispositif: 0; Vitesse: 0 m/s
Isolation - Epaisseur d'isolation: 0 mm; sets with these values: 2
Phase de construction - Phase de création: Nouvelle construction; sets with these values: 2
Pset_DistributionFlowElementCommon - Reference: Par défaut
Données d'identification(Type) - Nom du type: Par défaut
Autre(Type) - Catégorie: Canalisation; Nom de la famille: Canalisation
Name (Canalisation:Par défaut:...) | Décalage de départ (mm) = Décalage extrémité (mm) = Décaler (mm) | Diamètre extérieur (mm) | Diamètre intérieur (mm) | Longueur (mm) | Taille = Taille globale | Identifiant | Coupe | Diamètre (mm) | Inverser l'élévation (mm) | Surface (m2) | Rugosité relative | Contraintes, sets with these values = Génie climatique - Ecoulement, sets with these values
2314 | 251.5 | 88.9 | 77.9272 | 3.75 | 80 mmø | 135 | 2 | 80 | 212.536 | 0.000942478 | 0.000586701
2318 | 516.5 | 88.9 | 77.9272 | 11.251 | 80 mmø | 137 | 1 | 80 | 477.536 | 0.00282767 | 0.000586701 | 2
2320 | 516.5 | 26.67 | 20.9296 | 3.49949 | 20 mmø | 138 | 1 | 20 | 506.035 | 0.00021988 | 0.00218447 | 2 | Génie climatique - sets with these values: 2
2325 | 251.5 | 88.9 | 77.9272 | 40.715 | 80 mmø | 136 | 1 | 80 | 212.536 | 0.0102328 | 0.000586701 | 2 | Génie climatique - sets with these values: 2

# IfcFlowTerminal: Clarificateur 21/50, BWT_filtre Clarificateur GTC 21-50 Groupe:Clarificateur 21/50:2312
In: Niveau 1
Material: BWT_Noir, BWT_Laiton, BWT_Plastique blanc, INOX, Stratifié, bleu marine, BWT_Plastique rouge
Pset_ManufacturerTypeInformation - Manufacturer: BWT
Pset_DistributionFlowElementCommon - Reference: Clarificateur 21/50
Autre - Catégorie: Appareils sanitaires; Famille: BWT_filtre Clarificateur GTC 21-50 Groupe: Clarificateur 21/50; Famille et type: BWT_filtre Clarificateur GTC 21-50 Groupe: Clarificateur 21/50; ID du type: BWT_filtre Clarificateur GTC 21-50 Groupe: Clarificateur 21/50; Type: BWT_filtre Clarificateur GTC 21-50 Groupe: Clarificateur 21/50
Contraintes - Décalage: 146.5 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1
Cotes - Surface: 1.00764 m2; Volume: 0.0503726 m3
Données - BWT_URL_Produit: http://www.bwt.fr/fr/Documentations/Eau_dconsommation_Humaine/Adoucissement/Pages/default.aspx
Données d'identification - Identifiant: 90
Génie climatique - Classification du système: Aération,Eau froide sanitaire
Phase de construction - Phase de création: Nouvelle construction
Autre(Type) - Catégorie: Appareils sanitaires; Nom de la famille: BWT_filtre Clarificateur GTC 21-50 Groupe
Cotes(Type) - BWT_Hauteur: 1508 mm; BWT_Largeur: 480 mm; BWT_Profondeur: 1320 mm
Données d'identification(Type) - Description: Filtre; Fabricant: BWT; Modèle: Clarificateur 21/50 Solutech; Nom du type: Clarificateur 21/50; URL: http:\\www.bwt.fr
Données(Type) - BWT_CODE: P0003643; BWT_DN de raccordement: 80 mm; BWT_Element filtrant: poche; BWT_Matériau: Acier inoxydable; BWT_Pression maximum: 1000000 Pa; BWT_Seuil de filtration: 20 µm; BWT_Température maxi eau: 85 kg/K/s3; BWT_Température max local: 30 kg/K/s3; BWT_Température mini eau: 30 kg/K/s3; BWT_Température min local: 5 kg/K/s3; BWT_Tension électrique: 230 V; BWT_Type de raccordement: brides

# IfcFlowTerminal: Support, Support Solutech 21-50:Support:2313
In: Niveau 1
Material: BWT_Acier
Pset_DistributionFlowElementCommon - Reference: Support
Autre - Catégorie: Appareils sanitaires; Famille: Support Solutech 21-50: Support; Famille et type: Support Solutech 21-50: Support; ID du type: Support Solutech 21-50: Support; Type: Support Solutech 21-50: Support
Contraintes - Décalage: 0 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1; Se déplace avec les éléments voisins: no
Cotes - Surface: 0.33545 m2; Volume: 0.000509688 m3
Données d'identification - Identifiant: 93
Phase de construction - Phase de création: Nouvelle construction
Données d'identification(Type) - Description: Support; Nom du type: Support; URL: http:\\www.bwt.fr
Autre(Type) - Catégorie: Appareils sanitaires; Nom de la famille: Support Solutech 21-50
