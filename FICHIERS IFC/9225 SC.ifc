Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2017-03-22T14:00:01
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.5.0.0 - Interface alternative d'export 16.5.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 22 14:00:01 2017 * Host: LTBATREI25067 * Database: C:\Users\Blond\AppData\Local\Temp\{1EBB3828-8D3C-47E7-8233-C54F47A8C02B}\ifc * Database version: 5507 * Database creation date: Wed Mar 22 14:00:00 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 22 14:00:00 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 22 14:00:00 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: C:\Users\Blond\Desktop\Export IFC\Adouccisseur\FR\9225 SC.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Autre - Catégorie: Informations sur le projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Autre - Catégorie: Niveaux; Famille: Niveau: Niveau 1; Famille et type: Niveau: Niveau 1; ID du type: Niveau: Niveau 1; Type: Niveau: Niveau 1
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet
Données d'identification(Type) - Nom du type: Niveau 1
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Plein; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes

# IfcBuildingElementProxy: 1400 x 820 mm, BWT_Bac à sel type 1:1400 x 820 mm:2313
In: Niveau 1
Type - Material: Plastique PPS
Type - Autre(Type) - Catégorie: Modèles génériques; Nom de la famille: BWT_Bac à sel type 1
Type - Cotes(Type) - Diamètre: 820 mm; Hauteur: 1400 mm
Type - Données d'identification(Type) - Description: Bac à sel; Fabricant: BWT; Nom du type: 1400 x 820 mm; URL: http:\\www.bwt.fr
Pset_BuildingElementProxyCommon - Reference: 1400 x 820 mm
Pset_ManufacturerTypeInformation - Manufacturer: BWT
Autre - Catégorie: Modèles génériques; Famille: BWT_Bac à sel type 1: 1400 x 820 mm; Famille et type: BWT_Bac à sel type 1: 1400 x 820 mm; ID du type: BWT_Bac à sel type 1: 1400 x 820 mm; Type: BWT_Bac à sel type 1: 1400 x 820 mm
Contraintes - Décalage: 0 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1; Se déplace avec les éléments voisins: no
Cotes - Surface: 2.2108 m2; Volume: 0.687592 m3
Phase de construction - Phase de création: Nouvelle construction

# IfcDistributionPort (16)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
2 x InPort_2312
OutPort_2317
OutPort_2315
InPort_2314 | Group: Eau froide sanitaire 2
OutPort_2329 | Group: Eau froide sanitaire 2
2 x InPort_2314
2 x OutPort_2325
2 x OutPort_2323
InPort_2314 | Group: Eau froide sanitaire 1
OutPort_2327 | Group: Eau froide sanitaire 1
InPort_2315
InPort_2317

# IfcFlowController: BWT_Simply-connect Coudée, BWT_Simply-connect Coudée:BWT_Simply-connect Coudée:2314
In: Niveau 1
Type - Material: INOX, Laiton, Acier, Par défaut
Type - Autre(Type) - Catégorie: Accessoire de canalisation; Nom de la famille: BWT_Simply-connect Coudée
Type - Données d'identification(Type) - Fabricant: BWT; Modèle: Simply connect; Nom du type: BWT_Simply-connect Coudée
Type - Données(Type) - BWT_DN de raccordement: 50 mm
Pset_ManufacturerTypeInformation - Manufacturer: BWT
Pset_DistributionFlowElementCommon - Reference: BWT_Simply-connect Coudée
Autre - Catégorie: Accessoire de canalisation; Famille: BWT_Simply-connect Coudée: BWT_Simply-connect Coudée; Famille et type: BWT_Simply-connect Coudée: BWT_Simply-connect Coudée; ID du type: BWT_Simply-connect Coudée: BWT_Simply-connect Coudée; Type: BWT_Simply-connect Coudée: BWT_Simply-connect Coudée
Contraintes - Niveau: Niveau: Niveau 1; Décalage: 2000 mm; Hôte: Niveau : Niveau 1
Cotes - Surface: 0.142759 m2; Taille: 50 mmø-50 mmø-50 mmø-50 mmø; Taille maximale: 50 mm; Taille minimale: 50 mm; Volume: 0.00182495 m3
Données d'identification - Identifiant: 199
Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau froide sanitaire 1,Eau froide sanitaire 2; Type de système: Système de canalisation: Eau froide sanitaire
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 50 mmø-50 mmø-50 mmø-50 mmø
Phase de construction - Phase de création: Nouvelle construction
Group: Eau froide sanitaire 2; Eau froide sanitaire 1

# IfcFlowSegment: Canalisation souple arrondie:Souple - Circulaire (2)
In: Niveau 1
Autre - Catégorie: Canalisation souple; Famille: Canalisation souple arrondie: Souple - Circulaire; Famille et type: Canalisation souple arrondie: Souple - Circulaire; ID du type: Canalisation souple arrondie: Souple - Circulaire; Type: Canalisation souple arrondie: Souple - Circulaire; sets with these values: 2
Contraintes - Niveau de référence: Niveau: Niveau 1; Décalage de départ: 1693.6 mm; sets with these values: 2
Cotes - Diamètre extérieur: 50 mm; Diamètre intérieur: 50 mm; sets with these values: 2
Données d'identification - sets with these values: 2
Génie climatique - Classification du système: Non défini; Diamètre: 50 mm; sets with these values: 2
Génie climatique - Ecoulement - Etat du flux: Laminaire; Facteur de frottement: 0; Frottement: 0; Nombre de Reynolds: 0; Unités du dispositif: 0; Flux: 0 m3/s; Flux supplémentaire: 0 m3/s; Perte de charge: 0 Pa; Rugosité relative: 0.0009144; Vitesse: 0 m/s; sets with these values: 2
Graphismes - Modèle de gaine flexible: A voie unique; sets with these values: 2
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 50 mmø; sets with these values: 2
Phase de construction - Phase de création: Nouvelle construction; sets with these values: 2
Pset_DistributionFlowElementCommon - Reference: Souple - Circulaire
Autre(Type) - Catégorie: Canalisation souple; Nom de la famille: Canalisation souple arrondie
Données d'identification(Type) - Nom du type: Souple - Circulaire
Génie climatique(Type) - Rugosité: 0.04572 mm
Raccords(Type) - Té: Té - Générique: Standard; Transition: Transformation - Générique: Standard; Type de jonction préférée: Té; Union: Manchon - Générique: Standard
Name (Canalisation souple arrondie:Souple - Circulaire:...) | Longueur (mm) | Identifiant | Coupe
2323 | 550.315 | 40 | 2
2325 | 550.091 | 41 | 1

# IfcFlowSegment: Canalisation:Standard (4)
In: Niveau 1
Autre - Catégorie: Canalisation; Famille: Canalisation: Standard; Famille et type: Canalisation: Standard; ID du type: Canalisation: Standard; Type: Canalisation: Standard; sets with these values: 2
Contraintes - Inclinaison: 0; Justification horizontale: Centre; Justification verticale: Milieu; Niveau de référence: Niveau: Niveau 1
Cotes - Diamètre extérieur: 60.325 mm; Diamètre intérieur: 52.5018 mm; Taille: 50 mmø; sets with these values: 2
Données d'identification - sets with these values: 2
Génie climatique - Diamètre: 50 mm; Matériau: Acier, carbone; Nomenclature/type: Types de nomenclatures de canalisations: Nomenclature 40; Rugosité: 0.04572 mm; Segment de canalisation: Acier au carbone - Série 40; Type de connexion: Générique
Génie climatique - Ecoulement - Etat du flux: Laminaire; Facteur de frottement: 0; Flux: 0 m3/s; Flux supplémentaire: 0 m3/s; Frottement: 0; Nombre de Reynolds: 0; Perte de charge: 0 Pa; Rugosité relative: 0.000870827; Unités du dispositif: 0; Vitesse: 0 m/s
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 50 mmø; sets with these values: 2
Phase de construction - Phase de création: Nouvelle construction; sets with these values: 2
Pset_DistributionFlowElementCommon - Reference: Standard
Autre(Type) - Catégorie: Canalisation; Nom de la famille: Canalisation
Données d'identification(Type) - Nom du type: Standard
Name (Canalisation:Standard:...) | Décalage de départ (mm) = Décaler (mm) | Décalage extrémité (mm) | Longueur (mm) | Identifiant | Classification du système | Coupe | Inverser l'élévation (mm) | Surface (m2) | Contraintes, sets with these values = Génie climatique - Ecoulement, sets with these values
2315 | 1693.59 | 1693.6 | 5.04163 | 288 | Non défini | 1 | 1667.34 | 0.000791937
2317 | 1693.59 | 1693.6 | 5.04163 | 289 | Non défini | 2 | 1667.34 | 0.000791937 | 2
2327 | 2000 | 2000 | 300 | 294 | Eau froide sanitaire | 2 | 1973.75 | 0.0471239 | 2 | Génie climatique - Type de système: Système de canalisation: Eau froide sanitaire; Nom du système: Eau froide sanitaire 1; sets with these values: 2; Group: Eau froide sanitaire 1
2329 | 2000 | 2000 | 300 | 295 | Eau froide sanitaire | 2 | 1973.75 | 0.0471239 | 2 | Génie climatique - Type de système: Système de canalisation: Eau froide sanitaire; Nom du système: Eau froide sanitaire 2; sets with these values: 2; Group: Eau froide sanitaire 2

# IfcFlowTerminal: 9225SC, BWT_9000SC:9225SC:2312
In: Niveau 1
Material: Plastique, noir opaque, Plastique, blanc opaque, Acier, moulé, Cuivre, Bouton Rouge, Metal bleu
Pset_ManufacturerTypeInformation - Manufacturer: BWT_FRANCE
Pset_DistributionFlowElementCommon - Reference: 9225SC
Autre - Catégorie: Appareils sanitaires; Famille: BWT_9000SC: 9225SC; Famille et type: BWT_9000SC: 9225SC; ID du type: BWT_9000SC: 9225SC; Type: BWT_9000SC: 9225SC
Contraintes - Décalage: 0 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1
Cotes - Surface: 2.66821 m2; Volume: 0.378592 m3
Données - BWT_URL_Produit: http://www.bwt.fr/fr/Documentations/Eau_dconsommation_Humaine/Adoucissement/Pages/default.aspx
Données d'identification - Identifiant: 27
Génie climatique - Classification du système: Eau froide sanitaire
Phase de construction - Phase de création: Nouvelle construction
Autre(Type) - Catégorie: Appareils sanitaires; BWT_Ecart Logo: 230 mm; BWT_Hauteur cylindre: 480 mm; BWT_Hauteur de raccordment: 1700 mm; BWT_Hauteur Logo: 850 mm; BWT-Hauteur socle: 185 mm; BWT-Hauteur socle ecran de contrôle: 38.4 mm; Nom de la famille: BWT_9000SC
Cotes(Type) - BWT_Diamètre: 550 mm; BWT_Hauteur: 1930 mm; BWT_Hauteur bac à sel: 1400 mm; BWT_Hauteur bouteille: 1635 mm; BWT_Largeur bac à sel: 820 mm
Données d'identification(Type) - Description: Adoucisseur; Fabricant: BWT_FRANCE; Modèle: 9225SC; Nom du type: 9225SC; URL: http:\\www.bwt.fr
Données(Type) - BWT_ACS: yes; BWT_Capacité bac à sel: 300; BWT_Capacité d'échange (°f.m3): 1350; BWT_CODE: BK09225SC50; BWT_Consommation électrique en regénération: 50 W; BWT_Consommation électrique normale: 10 W; BWT_Débit à TH0° F: 0.147144 m3/s; BWT_Débit eau de rejet: 0.0225621 m3/s; BWT_DN de raccordement: 50 mm; BWT_Masse en service (kg/m2): 1000; BWT_Origine France Garantie: yes; BWT_Pression maximum: 700000 Pa; BWT_Pression minimum: 150000 Pa; BWT_Température maxi eau: 35 kg/K/s3; BWT_Température max local: 40 kg/K/s3; BWT_Température mini eau: 5 kg/K/s3; BWT_Température min local: 5 kg/K/s3; BWT_Tension électrique: 230 V; BWT_Volume de résine: 0.225 m3
Matériaux et finitions(Type) - Matériau 3: Plastique, blanc opaque

# IfcSystem: Eau froide sanitaire (2)
Autre - Catégorie: Système de canalisation; Famille: Système de canalisation: Eau froide sanitaire; Famille et type: Système de canalisation: Eau froide sanitaire; ID du type: Système de canalisation: Eau froide sanitaire; Type: Système de canalisation: Eau froide sanitaire
Génie climatique - Unités du dispositif: 0; Nombre d'éléments: 0; Volume: 0.000919394 m3
Génie climatique - Ecoulement - Flux: 0 m3/s
Name | Nom du système
Eau froide sanitaire 2 | Eau froide sanitaire 2
Eau froide sanitaire 1 | Eau froide sanitaire 1
