Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2017-03-22T11:48:31
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.5.0.0 - Interface alternative d'export 16.5.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 22 11:48:31 2017 * Host: LTBATREI25067 * Database: C:\Users\Blond\AppData\Local\Temp\{24973357-EFFD-4316-B8D3-34CAE757E55C}\ifc * Database version: 5507 * Database creation date: Wed Mar 22 11:48:31 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 22 11:48:31 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 22 11:48:31 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 52, 0, 117187; RefLongitude: 2, 19, 59, 880409; RefElevation: 0 mm
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Centre; Symbole: Marqueur de niveau - Cercle: Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Pointe 8 mm
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Autre - Catégorie: Niveaux; Famille: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; ID du type: Niveau: Pointe 8 mm; Type: Niveau: Pointe 8 mm
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no

# IfcFlowController: Infinity A 4", BWT_Filtre Infinity A 4 pouces:Infinity A 4":176137
In: Niveau 1
Type - Material: Verre opaque, UHMW, noir, Laiton, PVC, souple, BWT_Plastique noir
Type - Autre(Type) - Catégorie: Accessoire de canalisation; Nom de la famille: BWT_Filtre Infinity A 4 pouces
Type - Cotes(Type) - BWT_Hauteur: 690 mm; BWT_Largeur: 350 mm
Type - Données d'identification(Type) - Description: Filtre; Fabricant: BWT; Modèle: Infinity A; Nom du type: Infinity A 4"; Numéro OmniClass: 23.60.10.17; Titre OmniClass: Flow Meters
Type - Données(Type) - BWT_CODE: PK0033938A; BWT_DN de raccordement: 100 mm; BWT_Element filtrant: tamis; BWT_Seuil de filtration: 90/110 µm; BWT_Tension électrique: 230 V
Type - Matériaux et finitions(Type) - Matériau 1: BWT_Plastique noir; Matériau 2: Verre opaque; Matériau 3: Stratifié, bleu marine; Matériau 4: Laiton
Pset_ManufacturerTypeInformation - Manufacturer: BWT
Pset_DistributionFlowElementCommon - Reference: Infinity A 4"
Autre - Catégorie: Accessoire de canalisation; Famille: BWT_Filtre Infinity A 4 pouces: Infinity A 4"; Famille et type: BWT_Filtre Infinity A 4 pouces: Infinity A 4"; ID du type: BWT_Filtre Infinity A 4 pouces: Infinity A 4"; Type: BWT_Filtre Infinity A 4 pouces: Infinity A 4"
Contraintes - Décalage: 0 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1
Cotes - Surface: 0.54563 m2; Taille: 100 mmø-100 mmø; Taille maximale: 100 mm; Taille minimale: 100 mm; Volume: 0.0284736 m3
Données d'identification - Identifiant: 6
Génie climatique - Classification du système: Non défini
Graphismes - Utiliser l'échelle d'annotations: no
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 100 mmø-100 mmø
Phase de construction - Phase de création: Phase 1
