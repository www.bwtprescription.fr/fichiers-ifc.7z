Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2017-03-22T11:56:37
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.5.0.0 - Interface alternative d'export 16.5.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 22 11:56:37 2017 * Host: LTBATREI25067 * Database: C:\Users\Blond\AppData\Local\Temp\{DA214E58-B9E2-437B-925E-CBCF0060225D}\ifc * Database version: 5507 * Database creation date: Wed Mar 22 11:56:37 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 22 11:56:37 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 22 11:56:37 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 52, 0, 117187; RefLongitude: 2, 19, 59, 880409; RefElevation: 0 mm
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Centre; Symbole: Marqueur de niveau - Cercle: Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Pointe 8 mm
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Autre - Catégorie: Niveaux; Famille: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; ID du type: Niveau: Pointe 8 mm; Type: Niveau: Pointe 8 mm
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no

# IfcFlowTerminal: 1500 Neutralite, BWT_filtre 1500:1500 Neutralite:176396
In: Niveau 1
Material: Plastique, noir opaque, Stratifié, bleu marine, Plastique ABS, UHMW, noir, INOX
Données(Type) - BWT_CODE: PK0001791; BWT_DN de raccordement: 40 mm; BWT_Element filtrant: média; BWT_Matériau: Fonte; BWT_Pression maximum: 700000 Pa; BWT_Température maxi eau: 35 kg/K/s3; BWT_Température max local: 40 kg/K/s3; BWT_Température mini eau: 5 kg/K/s3; BWT_Température min local: 5 kg/K/s3; BWT_Tension électrique: 230 V; BWT_Type de raccordement: taraudé
Données d'identification(Type) - Description: Filtre; Fabricant: BWT; Modèle: 1500 Neutralite; Nom du type: 1500 Neutralite; URL: http:\\www.bwt.fr
Pset_ManufacturerTypeInformation - Manufacturer: BWT
Pset_DistributionFlowElementCommon - Reference: 1500 Neutralite
Autre - Catégorie: Appareils sanitaires; Famille: BWT_filtre 1500: 1500 Neutralite; Famille et type: BWT_filtre 1500: 1500 Neutralite; ID du type: BWT_filtre 1500: 1500 Neutralite; Type: BWT_filtre 1500: 1500 Neutralite
Contraintes - Décalage: 0 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1
Cotes - Surface: 1.71143 m2; Volume: 0.216363 m3
Données d'identification - Identifiant: 3
Génie climatique - Classification du système: Eau froide sanitaire
Phase de construction - Phase de création: Phase 1
Autre(Type) - Catégorie: Appareils sanitaires; BWT_Hauteur Ecran de contrôle: 215 mm; BWT_Hauteur socle: 88 mm; Nom de la famille: BWT_filtre 1500
Cotes(Type) - BWT_Diamètre: 400 mm; BWT_Hauteur: 1910 mm
