Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2017-03-23T16:12:04
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.5.0.0 - Interface alternative d'export 16.5.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Mar 23 16:12:04 2017 * Host: LTBATREI25067 * Database: C:\Users\Blond\AppData\Local\Temp\{FCBBD1D4-D9D5-44FF-9658-149EFFF9EEE2}\ifc * Database version: 5507 * Database creation date: Thu Mar 23 16:12:04 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Mar 23 16:12:04 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Mar 23 16:12:04 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: BWT 3eme Serie

# IfcSite, Default
RefLatitude: 48, 51, 23, 807373; RefLongitude: 2, 21, 7, 999076; RefElevation: 0 mm
Autre - Catégorie: Informations sur le projet; Nom du client: BWT; Nom du projet: BWT 3eme Serie; Numéro de projet: 0001

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Nom du client: BWT; Nom du projet: BWT 3eme Serie; Numéro de projet: 0001

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: 0 mm
Autre - Catégorie: Niveaux; Famille: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; ID du type: Niveau: Pointe 8 mm; Type: Niveau: Pointe 8 mm
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 0; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet
Données d'identification(Type) - Nom du type: Pointe 8 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Plein; Symbole: Marqueur de niveau - Cercle: Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes

# IfcDistributionPort (6)
Description: Flow
Name | FlowDirection | Group
2 x InPort_755273 | SOURCEANDSINK | Eau Froide Sanitaire 3
OutPort_993806 | SOURCEANDSINK | Eau Froide Sanitaire 3
InPort_1212566 | SINK | Autre 2
OutPort_755273 | SOURCE | Autre 2
OutPort_993808 | SOURCEANDSINK | Eau Froide Sanitaire 3

# IfcFlowSegment: Canalisation souple arrondie:Souple - Circulaire (3)
In: Niveau 0
Autre - Catégorie: Canalisation souple; Famille: Canalisation souple arrondie: Souple - Circulaire; Famille et type: Canalisation souple arrondie: Souple - Circulaire; ID du type: Canalisation souple arrondie: Souple - Circulaire; Type: Canalisation souple arrondie: Souple - Circulaire; sets with these values: 2
Contraintes - Décalage de départ: 1026.92 mm; Niveau de référence: Niveau: Niveau 0
Cotes - sets with these values: 2
Données d'identification - sets with these values: 2
Graphismes - Modèle de gaine flexible: A voie unique; sets with these values: 2
Isolation - Epaisseur d'isolation: 0 mm; sets with these values: 2
Phase de construction - Phase de création: Nouvelle construction; sets with these values: 2
Pset_DistributionFlowElementCommon - Reference: Souple - Circulaire
Autre(Type) - Catégorie: Canalisation souple; Nom de la famille: Canalisation souple arrondie
Données d'identification(Type) - Nom du type: Souple - Circulaire
Génie climatique(Type) - Rugosité: 0.04572 mm
Raccords(Type) - Té: Té - Générique: Standard; Transition: Transformation - Générique: Standard; Type de jonction préférée: Té; Union: Manchon - Générique: Standard
Name (Canalisation souple arrondie:Souple - Circulaire:...) | Diamètre extérieur (mm) = Diamètre intérieur (mm) = Diamètre (mm) | Longueur (mm) | Identifiant | Classification du système | Coupe | Nom du système = Group | Type de système | Etat du flux | Facteur de frottement = Flux (m3/s) = Flux supplémentaire (m3/s) = Frottement = Nombre de Reynolds = Perte de charge (Pa) = Unités du dispositif = Vitesse (m/s) | Rugosité relative | Taille globale | Contraintes, sets with these values = Génie climatique - Ecoulement, sets with these values
993806 | 20 | 318.479 | 3 | Eau froide sanitaire | 1 | Eau Froide Sanitaire 3 | Système de canalisation: Eau Froide Sanitaire | Laminaire | 0 | 0.002286 | 20 mmø
993808 | 20 | 318.498 | 4 | Eau froide sanitaire | 2 | Eau Froide Sanitaire 3 | Système de canalisation: Eau Froide Sanitaire | Laminaire | 0 | 0.002286 | 20 mmø | 2
1212566 | 8 | 835.129 | 10 | Autre | 1 | Autre 2 | Système de canalisation: Autre |  |  | 0.005715 | 8 mmø | 2

# IfcFlowTerminal: Permaq Eco Off-line, BWT_Permaq Eco:Permaq Eco Off-line:755273
In: Niveau 0
Material: Stratifié, bleu marine, BWT_Ecran, BWT_Plastique blanc, Acier, galvanisé, BWT_Plastique gris, Plastique ABS; Group: Eau Froide Sanitaire 3; Autre 2
Pset_ManufacturerTypeInformation - Manufacturer: BWT_FRANCE
Pset_DistributionFlowElementCommon - Reference: Permaq Eco Off-line
Autre - Catégorie: Appareils sanitaires; Famille: BWT_Permaq Eco: Permaq Eco Off-line; Famille et type: BWT_Permaq Eco: Permaq Eco Off-line; ID du type: BWT_Permaq Eco: Permaq Eco Off-line; Type: BWT_Permaq Eco: Permaq Eco Off-line
Contraintes - Décalage: 0 mm; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0
Cotes - Surface: 0.903341 m2; Volume: 0.0465612 m3
Données d'identification - Identifiant: 29
Génie climatique - Classification du système: Eau froide sanitaire,Autre; Nom du système: Eau Froide Sanitaire 3,Autre 2
Phase de construction - Phase de création: Nouvelle construction
Autre(Type) - Catégorie: Appareils sanitaires; Nom de la famille: BWT_Permaq Eco
Cotes(Type) - BWT_DN raccordement condensat: 8 mm; BWT_Hauteur: 1700 mm; BWT_Largeur: 200 mm; BWT_Profondeur: 200 mm
Données d'identification(Type) - Description: Osmoseur; Fabricant: BWT_FRANCE; Modèle: Permaq Eco Off-line; Nom du type: Permaq Eco Off-line; URL: http:\\www.bwt.fr
Données(Type) - BWT_CODE: PK0004577; BWT_Consommation électrique normale: 950 W; BWT_Débit perméat 10°C: 0.000036 m3/s; BWT_DN de raccordement: 20 mm; BWT_Masse en service (Vide): 60; BWT_Pression max eau alimentation: 600000 Pa; BWT_Pression min eau alimentation: 250000 Pa; BWT_Température maxi eau: 25 kg/K/s3; BWT_Température max local: 35 kg/K/s3; BWT_Température mini eau: 10 kg/K/s3; BWT_Température min local: 5 kg/K/s3; BWT_Tension électrique: 230 V; BWT_Volume réservoir perméat: 0 m3
Matériaux et finitions(Type) - Matériau 1: BWT_Plastique blanc; Matériau 2: BWT_Plastique gris; Matériau 3: Acier, galvanisé; Matériau 4: Stratifié, bleu marine

# IfcSystem: Autre, Autre 2
Autre - Catégorie: Système de canalisation; Famille: Système de canalisation: Autre; Famille et type: Système de canalisation: Autre; ID du type: Système de canalisation: Autre; Type: Système de canalisation: Autre
Génie climatique - Nombre d'éléments: 1; Nom du système: Autre 2; Volume: 0.0000419782 m3

# IfcSystem: Eau Froide Sanitaire, Eau Froide Sanitaire 3
Autre - Catégorie: Système de canalisation; Famille: Système de canalisation: Eau Froide Sanitaire; Famille et type: Système de canalisation: Eau Froide Sanitaire; ID du type: Système de canalisation: Eau Froide Sanitaire; Type: Système de canalisation: Eau Froide Sanitaire
Génie climatique - Unités du dispositif: 0; Nombre d'éléments: 0; Nom du système: Eau Froide Sanitaire 3; Volume: 0.000200112 m3
Génie climatique - Ecoulement - Flux: 0 m3/s
