Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2017-06-30T11:30:34
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.5.0.0 - Interface alternative d'export 16.5.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jun 30 11:30:34 2017 * Host: LTBATREI25067 * Database: C:\Users\Blond\AppData\Local\Temp\{1828C545-19E0-4976-B2DD-E2A469936275}\ifc * Database version: 5507 * Database creation date: Fri Jun 30 11:30:33 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jun 30 11:30:33 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jun 30 11:30:33 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: BWT 4ème serie; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 52, 0, 117187; RefLongitude: 2, 19, 59, 880409; RefElevation: 0 mm
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: BWT 4ème serie; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: BWT 4ème serie; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Centre; Symbole: Marqueur de niveau - Cercle: Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Pointe 8 mm
Autre - Catégorie: Niveaux; Famille: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; ID du type: Niveau: Pointe 8 mm; Type: Niveau: Pointe 8 mm
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet

# IfcFlowController: SOLUTECH ECHANGEUR, BWT_SOLUTECH ECHANGEUR:SOLUTECH ECHANGEUR:142810
In: Niveau 1
Type - Material: BWT_Acier inoxydable, Stratifié, bleu marine
Type - Autre(Type) - Catégorie: Accessoire de canalisation; Nom de la famille: BWT_SOLUTECH ECHANGEUR
Type - Cotes(Type) - BWT_Hauteur: 35 mm; BWT_Largeur: 230 mm; BWT_Profondeur: 35 mm
Type - Données d'identification(Type) - Description: Antitartre; Fabricant: BWT_FRANCE; Modèle: Solutech echangeur; Nom du type: SOLUTECH ECHANGEUR; URL: http:\\www.bwt.fr
Type - Données(Type) - BWT_CODE: C0502030; BWT_Débit maximal: 0.0206002 m3/s; BWT_DN de raccordement: 16 mm; BWT_Masse en service (Vide): 0.8; BWT_Matériau: Laiton; BWT_Pression maximum: 1000000 Pa; BWT_Température maxi eau: 70 kg/K/s3; BWT_Température max local: 40 kg/K/s3; BWT_Température mini eau: 5 kg/K/s3; BWT_Température min local: 5 kg/K/s3; BWT_Type de raccordement: écrou+olive
Type - Matériaux et finitions(Type) - Matériau 1: BWT_Acier inoxydable
Pset_ManufacturerTypeInformation - Manufacturer: BWT_FRANCE
Pset_DistributionFlowElementCommon - Reference: SOLUTECH ECHANGEUR
Autre - Catégorie: Accessoire de canalisation; Famille: BWT_SOLUTECH ECHANGEUR: SOLUTECH ECHANGEUR; Famille et type: BWT_SOLUTECH ECHANGEUR: SOLUTECH ECHANGEUR; ID du type: BWT_SOLUTECH ECHANGEUR: SOLUTECH ECHANGEUR; Type: BWT_SOLUTECH ECHANGEUR: SOLUTECH ECHANGEUR
Contraintes - Décalage: 0 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1
Cotes - Surface: 0.01342 m2; Taille: 16 mmø-16 mmø; Taille maximale: 16 mm; Taille minimale: 16 mm; Volume: 0.154894 dm3
Données d'identification - Identifiant: 1
Génie climatique - Classification du système: Eau froide sanitaire
Graphismes - Utiliser l'échelle d'annotations: no
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 16 mmø-16 mmø
Phase de construction - Phase de création: Phase 1
