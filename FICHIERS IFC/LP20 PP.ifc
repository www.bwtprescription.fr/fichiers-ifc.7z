Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2017-03-22T11:52:12
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.5.0.0 - Interface alternative d'export 16.5.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 22 11:52:12 2017 * Host: LTBATREI25067 * Database: C:\Users\Blond\AppData\Local\Temp\{AFC79A9F-32DE-4173-817C-AAF811ADCDDA}\ifc * Database version: 5507 * Database creation date: Wed Mar 22 11:52:12 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 22 11:52:12 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 22 11:52:12 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 52, 0, 117187; RefLongitude: 2, 19, 59, 880409; RefElevation: 0 mm
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Centre; Symbole: Marqueur de niveau - Cercle: Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Pointe 8 mm
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Autre - Catégorie: Niveaux; Famille: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; ID du type: Niveau: Pointe 8 mm; Type: Niveau: Pointe 8 mm
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no

# IfcFlowController: LP20 PP, BWT_Filtre LP:LP20 PP:176265
In: Niveau 1
Type - Material: Laiton, PVC, souple, Aluminium, anodisé rouge, Acier, Stratifié, bleu marine
Type - Autre(Type) - Catégorie: Accessoire de canalisation; Nom de la famille: BWT_Filtre LP
Type - Données d'identification(Type) - Description: Filtre; Fabricant: BWT; Modèle: LP20; Nom du type: LP20 PP; Numéro OmniClass: 23.60.10.17; Titre OmniClass: Flow Meters
Type - Données(Type) - BWT_CODE: P0048320; BWT_Débit maximal 0,2-1µm: 0.0147144 m3/s; BWT_Débit maximal 10-50µm: 0.0196173 m3/s; BWT_Débit maximal CA: 0.00588578 m3/s; BWT_DN de raccordement: 20 mm; BWT_Element filtrant: cartouche; BWT_Matériau: Polypropylène; BWT_Pression maximum: 800000 Pa; BWT_Température maxi eau: 50 kg/K/s3; BWT_Température mini eau: 5 kg/K/s3; BWT_Type de raccordement: taraudé
Type - Matériaux et finitions(Type) - Matériau 1: Stratifié, bleu marine; Matériau 2: PVC, souple; Matériau 3: Acier
Type - Visibilité(Type) - LP10: no; LP20: yes
Pset_ManufacturerTypeInformation - Manufacturer: BWT
Pset_DistributionFlowElementCommon - Reference: LP20 PP
Autre - Catégorie: Accessoire de canalisation; Famille: BWT_Filtre LP: LP20 PP; Famille et type: BWT_Filtre LP: LP20 PP; ID du type: BWT_Filtre LP: LP20 PP; Type: BWT_Filtre LP: LP20 PP
Contraintes - Décalage: 0 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1
Cotes - Surface: 0.191381 m2; Taille: 20 mmø-20 mmø; Taille maximale: 20 mm; Taille minimale: 20 mm; Volume: 0.00495697 m3
Données d'identification - Identifiant: 14
Génie climatique - Classification du système: Non défini
Génie climatique - Ecoulement - Perte de charge: 0 Pa
Graphismes - Utiliser l'échelle d'annotations: no
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 20 mmø-20 mmø
Phase de construction - Phase de création: Phase 1
