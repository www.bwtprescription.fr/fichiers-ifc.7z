Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2017-03-22T11:56:58
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.5.0.0 - Interface alternative d'export 16.5.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 22 11:56:58 2017 * Host: LTBATREI25067 * Database: C:\Users\Blond\AppData\Local\Temp\{F43AB991-0763-416E-B7C7-FE34B571CE19}\ifc * Database version: 5507 * Database creation date: Wed Mar 22 11:56:57 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 22 11:56:58 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 22 11:56:58 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 52, 0, 117187; RefLongitude: 2, 19, 59, 880409; RefElevation: 0 mm
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Centre; Symbole: Marqueur de niveau - Cercle: Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Pointe 8 mm
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Autre - Catégorie: Niveaux; Famille: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; ID du type: Niveau: Pointe 8 mm; Type: Niveau: Pointe 8 mm
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no

# IfcFlowTerminal: 3055, BWT_filtre 3000:3055:176422
In: Niveau 1
Material: Laiton, Plastique, noir opaque, Acier, moulé, Bouton Rouge, Plastique, blanc opaque, Plastique bleu
Visibilité(Type) - Visibilité socle 3077: no
Matériaux et finitions(Type) - Matériau 1: Plastique, noir opaque; Matériau 2: Plastique bleu; Matériau 3: Plastique, blanc opaque
Pset_ManufacturerTypeInformation - Manufacturer: BWT
Pset_DistributionFlowElementCommon - Reference: 3055
Autre - Catégorie: Appareils sanitaires; Famille: BWT_filtre 3000: 3055; Famille et type: BWT_filtre 3000: 3055; ID du type: BWT_filtre 3000: 3055; Type: BWT_filtre 3000: 3055
Contraintes - Décalage: 0 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1
Cotes - Surface: 2.97455 m2; Volume: 0.380494 m3
Données d'identification - Identifiant: 4
Génie climatique - Classification du système: Eau froide sanitaire
Phase de construction - Phase de création: Phase 1
Autre(Type) - Catégorie: Appareils sanitaires; BWT_Ecart Logo: 237.5 mm; BWT_Hauteur de col: 10 mm; BWT_Hauteur Logo: 697.5 mm; BWT-Hauteur socle: 170 mm; Nom de la famille: BWT_filtre 3000
Cotes(Type) - BWT_Diamètre: 550 mm; BWT_Hauteur: 1945 mm; BWT_Hauteur bouteille: 1660 mm
Données d'identification(Type) - Description: Filtre; Fabricant: BWT; Modèle: 3055; Nom du type: 3055; URL: http:\\www.bwt.fr
Données(Type) - BWT_CODE: BK0003055; BWT_DN de raccordement: 50 mm; BWT_Element filtrant: média; BWT_Masse en service: 450; BWT_Matériau: Laiton; BWT_Pression maximum: 700000 Pa; BWT_Température maxi eau: 35 kg/K/s3; BWT_Température max local: 40 kg/K/s3; BWT_Température mini eau: 5 kg/K/s3; BWT_Température min local: 5 kg/K/s3; BWT_Tension électrique: 230 V; BWT_Type de raccordement: taraudé; Débit de lavage (bicouche, déferrisation): 0.078477 m3/s; Débit de lavage (monocouche, charbon actif, neutralisation): 0.0490481 m3/s; Débit maximal (bicouche, déferrisation): 0.078477 m3/s; Débit maximal (monocouche, charbon actif, neutralisation): 0.0686674 m3/s
