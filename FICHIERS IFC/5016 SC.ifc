Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2017-03-22T13:55:59
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.5.0.0 - Interface alternative d'export 16.5.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 22 13:55:59 2017 * Host: LTBATREI25067 * Database: C:\Users\Blond\AppData\Local\Temp\{1F90314A-EF42-4C0D-BEE7-6D01DAA4C076}\ifc * Database version: 5507 * Database creation date: Wed Mar 22 13:55:58 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 22 13:55:58 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 22 13:55:58 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: C:\Users\Blond\Desktop\Export IFC\Adouccisseur\FR\5016 SC.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Autre - Catégorie: Informations sur le projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Autre - Catégorie: Niveaux; Famille: Niveau: Niveau 1; Famille et type: Niveau: Niveau 1; ID du type: Niveau: Niveau 1; Type: Niveau: Niveau 1
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet
Données d'identification(Type) - Nom du type: Niveau 1
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Plein; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes

# IfcDistributionPort (12)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
2 x InPort_2312
2 x OutPort_2318
2 x OutPort_2320
2 x InPort_2313
InPort_2313 | Group: Eau froide sanitaire 1
OutPort_2314 | Group: Eau froide sanitaire 1
InPort_2313 | Group: Eau froide sanitaire 2
OutPort_2316 | Group: Eau froide sanitaire 2

# IfcFlowController: Module By-pass, BWT_By-pass:Module By-pass:2313
In: Niveau 1
Type - Material: Laiton, Par défaut
Type - Autre(Type) - Catégorie: Accessoire de canalisation; Nom de la famille: BWT_By-pass
Type - Cotes(Type) - Rayon: 12.5 mm
Type - Données d'identification(Type) - Fabricant: BWT; Modèle: Module By-pass; Nom du type: Module By-pass
Type - Données(Type) - BWT_DN de raccordement: 25 mm
Pset_ManufacturerTypeInformation - Manufacturer: BWT
Pset_DistributionFlowElementCommon - Reference: Module By-pass
Autre - Catégorie: Accessoire de canalisation; Famille: BWT_By-pass: Module By-pass; Famille et type: BWT_By-pass: Module By-pass; ID du type: BWT_By-pass: Module By-pass; Type: BWT_By-pass: Module By-pass
Contraintes - Décalage: 1100 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1
Cotes - Surface: 0.0266484 m2; Taille: 25 mmø-25 mmø-25 mmø-25 mmø; Taille maximale: 25 mm; Taille minimale: 25 mm; Volume: 0.000262401 m3
Données d'identification - Identifiant: 163
Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau froide sanitaire 2,Eau froide sanitaire 1; Type de système: Système de canalisation: Eau froide sanitaire
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 25 mmø-25 mmø-25 mmø-25 mmø
Phase de construction - Phase de création: Nouvelle construction
Group: Eau froide sanitaire 1; Eau froide sanitaire 2

# IfcFlowSegment: Canalisation souple arrondie:Souple - Circulaire (2)
In: Niveau 1
Autre - Catégorie: Canalisation souple; Famille: Canalisation souple arrondie: Souple - Circulaire; Famille et type: Canalisation souple arrondie: Souple - Circulaire; ID du type: Canalisation souple arrondie: Souple - Circulaire; Type: Canalisation souple arrondie: Souple - Circulaire; sets with these values: 2
Contraintes - Niveau de référence: Niveau: Niveau 1; Décalage de départ: 958.677 mm; sets with these values: 2
Cotes - Diamètre extérieur: 25 mm; Diamètre intérieur: 25 mm; sets with these values: 2
Données d'identification - sets with these values: 2
Génie climatique - Coupe: 1; Classification du système: Non défini; Diamètre: 25 mm; sets with these values: 2
Génie climatique - Ecoulement - Etat du flux: Laminaire; Facteur de frottement: 0; Frottement: 0; Nombre de Reynolds: 0; Unités du dispositif: 0; Flux: 0 m3/s; Flux supplémentaire: 0 m3/s; Perte de charge: 0 Pa; Rugosité relative: 0.0018288; Vitesse: 0 m/s; sets with these values: 2
Graphismes - Modèle de gaine flexible: A voie unique; sets with these values: 2
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 25 mmø; sets with these values: 2
Phase de construction - Phase de création: Nouvelle construction; sets with these values: 2
Pset_DistributionFlowElementCommon - Reference: Souple - Circulaire
Autre(Type) - Catégorie: Canalisation souple; Nom de la famille: Canalisation souple arrondie
Données d'identification(Type) - Nom du type: Souple - Circulaire
Génie climatique(Type) - Rugosité: 0.04572 mm
Raccords(Type) - Té: Té - Générique: Standard; Transition: Transformation - Générique: Standard; Type de jonction préférée: Té; Union: Manchon - Générique: Standard
Name (Canalisation souple arrondie:Souple - Circulaire:...) | Longueur (mm) | Identifiant
2318 | 552.707 | 12
2320 | 542.69 | 13

# IfcFlowSegment: Canalisation:Standard (2)
In: Niveau 1
Autre - Catégorie: Canalisation; Famille: Canalisation: Standard; Famille et type: Canalisation: Standard; ID du type: Canalisation: Standard; Type: Canalisation: Standard; sets with these values: 2
Contraintes - Décalage de départ: 1099.53 mm; Décalage extrémité: 1099.53 mm; Décaler: 1099.53 mm; Inclinaison: 0; Justification horizontale: Centre; Justification verticale: Milieu; Niveau de référence: Niveau: Niveau 1
Cotes - Diamètre extérieur: 33.401 mm; Diamètre intérieur: 26.6446 mm; Longueur: 300 mm; Taille: 25 mmø; sets with these values: 2
Données d'identification - sets with these values: 2
Génie climatique - Type de système: Système de canalisation: Eau froide sanitaire; Classification du système: Eau froide sanitaire; Coupe: 1; Diamètre: 25 mm; Inverser l'élévation: 1086.21 mm; Matériau: Acier, carbone; Nomenclature/type: Types de nomenclatures de canalisations: Nomenclature 40; Rugosité: 0.04572 mm; Segment de canalisation: Acier au carbone - Série 40; Surface: 0.0235619 m2; Type de connexion: Générique
Génie climatique - Ecoulement - Etat du flux: Laminaire; Facteur de frottement: 0; Flux: 0 m3/s; Flux supplémentaire: 0 m3/s; Frottement: 0; Nombre de Reynolds: 0; Perte de charge: 0 Pa; Rugosité relative: 0.00171592; Unités du dispositif: 0; Vitesse: 0 m/s
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 25 mmø; sets with these values: 2
Phase de construction - Phase de création: Nouvelle construction; sets with these values: 2
Pset_DistributionFlowElementCommon - Reference: Standard
Autre(Type) - Catégorie: Canalisation; Nom de la famille: Canalisation
Données d'identification(Type) - Nom du type: Standard
Name (Canalisation:Standard:...) | Identifiant | Nom du système = Group
2314 | 230 | Eau froide sanitaire 1
2316 | 231 | Eau froide sanitaire 2 | Contraintes - sets with these values: 2; Génie climatique - sets with these values: 2; Génie climatique - Ecoulement - sets with these values: 2

# IfcFlowTerminal: 5016SC, BWT_5016SC:5016SC:2312
In: Niveau 1
Material: Plastique, blanc opaque, Stratifié, bleu marine, Plastique ABS, Plastique, noir opaque
Pset_ManufacturerTypeInformation - Manufacturer: BWT_FRANCE
Pset_DistributionFlowElementCommon - Reference: 5016SC
Autre - Catégorie: Appareils sanitaires; Famille: BWT_5016SC: 5016SC; Famille et type: BWT_5016SC: 5016SC; ID du type: BWT_5016SC: 5016SC; Type: BWT_5016SC: 5016SC
Contraintes - Décalage: 0 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1
Cotes - Surface: 1.42078 m2; Volume: 0.197646 m3
Données - BWT_URL_Produit: http://www.bwt.fr/fr/Documentations/Eau_dconsommation_Humaine/Pages/default.aspx
Données d'identification - Identifiant: 1
Génie climatique - Classification du système: Eau froide sanitaire
Phase de construction - Phase de création: Nouvelle construction
Autre(Type) - Catégorie: Appareils sanitaires; BWT_Hauteur cylindre: 480 mm; BWT_Hauteur de raccordment: 960 mm; BWT-Hauteur socle ecran de contrôle: 38.4 mm; Nom de la famille: BWT_5016SC
Cotes(Type) - BWT_Hauteur: 1140 mm; BWT_Hauteur bouteille: 437.5 mm; BWT_Largeur: 410 mm; BWT_Largeur bac à sel: 550 mm; BWT_Longueur: 550 mm; BWT_Longueur bac à sel: 410 mm
Données d'identification(Type) - Description: Adoucisseur; Fabricant: BWT_FRANCE; Nom du type: 5016SC; URL: http:\\www.bwt.fr
Données(Type) - BWT_ACS: yes; BWT_Capacité bac à sel: 135; BWT_Capacité d'échange (°f.m3): 64-96; BWT_CODE: BK05016SC25; BWT_Consommation électrique en regénération: 50 W; BWT_Consommation électrique normale: 10 W; BWT_Débit à TH0° F: 0.0245241 m3/s; BWT_Débit eau de rejet: 0.0107906 m3/s; BWT_DN de raccordement: 25 mm; BWT_Origine France Garantie: yes; BWT_Pression maximum: 700000 Pa; BWT_Pression minimum: 150000 Pa; BWT_Température maxi eau: 35 kg/K/s3; BWT_Température max local: 40 kg/K/s3; BWT_Température mini eau: 5 kg/K/s3; BWT_Température min local: 5 kg/K/s3; BWT_Tension électrique: 230 V; BWT_Volume de résine: 0.016 m3

# IfcSystem: Eau froide sanitaire (2)
Autre - Catégorie: Système de canalisation; Famille: Système de canalisation: Eau froide sanitaire; Famille et type: Système de canalisation: Eau froide sanitaire; ID du type: Système de canalisation: Eau froide sanitaire; Type: Système de canalisation: Eau froide sanitaire
Génie climatique - Unités du dispositif: 0; Nombre d'éléments: 0
Génie climatique - Ecoulement - Flux: 0 m3/s
Name | Nom du système | Volume (m3)
Eau froide sanitaire 1 | Eau froide sanitaire 1 | 0.000205713
Eau froide sanitaire 2 | Eau froide sanitaire 2 | 0.000202576
