Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2017-03-22T13:59:36
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.5.0.0 - Interface alternative d'export 16.5.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 22 13:59:36 2017 * Host: LTBATREI25067 * Database: C:\Users\Blond\AppData\Local\Temp\{C6DFE58B-ED1E-42CD-8C5E-318E58FE767C}\ifc * Database version: 5507 * Database creation date: Wed Mar 22 13:59:35 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 22 13:59:35 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 22 13:59:35 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: C:\Users\Blond\Desktop\Export IFC\Adouccisseur\FR\8600 SC.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Autre - Catégorie: Informations sur le projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Plein; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Niveau 1
Autre - Catégorie: Niveaux; Famille: Niveau: Niveau 1; Famille et type: Niveau: Niveau 1; ID du type: Niveau: Niveau 1; Type: Niveau: Niveau 1
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet

# IfcBuildingElementProxy: 1560 x 1300 mm, BWT_Bac à sel type 1:1560 x 1300 mm:2313
In: Niveau 1
Type - Material: Plastique PPS
Type - Autre(Type) - Catégorie: Modèles génériques; Nom de la famille: BWT_Bac à sel type 1
Type - Cotes(Type) - Diamètre: 1300 mm; Hauteur: 1560 mm
Type - Données d'identification(Type) - Description: Bac à sel; Fabricant: BWT; Nom du type: 1560 x 1300 mm; URL: http:\\www.bwt.fr
Pset_BuildingElementProxyCommon - Reference: 1560 x 1300 mm
Pset_ManufacturerTypeInformation - Manufacturer: BWT
Autre - Catégorie: Modèles génériques; Famille: BWT_Bac à sel type 1: 1560 x 1300 mm; Famille et type: BWT_Bac à sel type 1: 1560 x 1300 mm; ID du type: BWT_Bac à sel type 1: 1560 x 1300 mm; Type: BWT_Bac à sel type 1: 1560 x 1300 mm
Contraintes - Décalage: 0 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1; Se déplace avec les éléments voisins: no
Cotes - Surface: 4.34943 m2; Volume: 1.97812 m3
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowTerminal: 8600SC, BWT_8600SC:8600SC:2312
In: Niveau 1
Material: Acier, moulé, Stratifié, bleu marine, Plastique ABS, Plastique bleu, Plastique, noir opaque, Cuivre, Plastique, blanc opaque, Bouton Rouge
Pset_ManufacturerTypeInformation - Manufacturer: BWT_FRANCE
Pset_DistributionFlowElementCommon - Reference: 8600SC
Autre - Catégorie: Appareils sanitaires; Famille: BWT_8600SC: 8600SC; Famille et type: BWT_8600SC: 8600SC; ID du type: BWT_8600SC: 8600SC; Type: BWT_8600SC: 8600SC
Contraintes - Décalage: 0 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1
Cotes - Surface: 5.57645 m2; Volume: 1.32439 m3
Données - BWT_URL_Produit: http://www.bwt.fr/fr/Documentations/Eau_dconsommation_Humaine/Adoucissement/Pages/default.aspx
Données d'identification - Identifiant: 14
Génie climatique - Classification du système: Eau froide sanitaire
Phase de construction - Phase de création: Nouvelle construction
Autre(Type) - Catégorie: Appareils sanitaires; BWT_Ecart_Bac à sel: 1500 mm; BWT_Ecart Logo: 420 mm; BWT_Hauteur cylindre: 480 mm; BWT_Hauteur de raccordment: 2280 mm; BWT_Hauteur Logo: 1000 mm; BWT-Hauteur socle: 323 mm; BWT-Hauteur socle ecran de contrôle: 38.4 mm; Nom de la famille: BWT_8600SC
Cotes(Type) - BWT_Diamètre: 930 mm; BWT_Hauteur: 2430 mm; BWT_Hauteur bac à sel: 1560 mm; BWT_Hauteur bouteille: 2099 mm; BWT_Largeur bac à sel: 1300 mm
Données d'identification(Type) - Description: Adoucisseur; Fabricant: BWT_FRANCE; Modèle: 8600SC; Nom du type: 8600SC; URL: http:\\www.bwt.fr
Données(Type) - BWT_ACS: yes; BWT_Capacité bac à sel: 1000; BWT_Capacité d'échange (°f.m3): 3000-3600; BWT_CODE: BK000008600; BWT_Consommation électrique en regénération: 50 W; BWT_Consommation électrique normale: 10 W; BWT_Débit à TH0° F: 0.245241 m3/s; BWT_Débit eau de rejet: 0.0980963 m3/s; BWT_DN de raccordement: 65 mm; BWT_Masse en service (kg/m2): 3000-4000; BWT_Origine France Garantie: yes; BWT_Pression maximum: 700000 Pa; BWT_Pression minimum: 150000 Pa; BWT_Température maxi eau: 35 kg/K/s3; BWT_Température max local: 40 kg/K/s3; BWT_Température mini eau: 5 kg/K/s3; BWT_Température min local: 5 kg/K/s3; BWT_Tension électrique: 230 V; BWT_Volume de résine: 0.6 m3
Matériaux et finitions(Type) - Matériau 1: Plastique, noir opaque; Matériau 2: Plastique bleu; Matériau 3: Plastique, blanc opaque
