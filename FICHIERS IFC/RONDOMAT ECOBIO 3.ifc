Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2017-03-22T13:53:29
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.5.0.0 - Interface alternative d'export 16.5.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 22 13:53:29 2017 * Host: LTBATREI25067 * Database: C:\Users\Blond\AppData\Local\Temp\{8C22EEED-645C-48DD-B104-0486FE97C6BE}\ifc * Database version: 5507 * Database creation date: Wed Mar 22 13:53:28 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 22 13:53:28 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 22 13:53:28 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: C:\Users\Blond\Desktop\Export IFC\Adouccisseur\FR\RONDOMAT ECOBIO 3.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Autre - Catégorie: Informations sur le projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Autre - Catégorie: Niveaux; Famille: Niveau: Niveau 1; Famille et type: Niveau: Niveau 1; ID du type: Niveau: Niveau 1; Type: Niveau: Niveau 1
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet
Données d'identification(Type) - Nom du type: Niveau 1
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Plein; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes

# IfcBuildingElementProxy: 630 x 470 mm, BWT_Bac à sel type 2:630 x 470 mm:2313
In: Niveau 1
Type - Material: Plastique PPS
Type - Autre(Type) - Catégorie: Modèles génériques; Nom de la famille: BWT_Bac à sel type 2
Type - Cotes(Type) - Diamètre: 482 mm; h1: 481 mm; Hauteur: 800 mm
Type - Données d'identification(Type) - Description: Bac à sel; Fabricant: BWT; Nom du type: 630 x 470 mm; URL: http:\\www.bwt.fr
Pset_BuildingElementProxyCommon - Reference: 630 x 470 mm
Pset_ManufacturerTypeInformation - Manufacturer: BWT
Autre - Catégorie: Modèles génériques; Famille: BWT_Bac à sel type 2: 630 x 470 mm; Famille et type: BWT_Bac à sel type 2: 630 x 470 mm; ID du type: BWT_Bac à sel type 2: 630 x 470 mm; Type: BWT_Bac à sel type 2: 630 x 470 mm
Contraintes - Décalage: 0 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1; Se déplace avec les éléments voisins: no
Cotes - Surface: 0.769402 m2; Volume: 0.1424 m3
Phase de construction - Phase de création: Nouvelle construction

# IfcDistributionPort (12)
Description: Flow; FlowDirection: SOURCEANDSINK; Group: Eau froide sanitaire 1
Name
2 x InPort_2312
2 x OutPort_2317
2 x OutPort_2315
4 x InPort_2314
OutPort_2319
OutPort_2321

# IfcFlowController: DN32, BWT_Simply-connect (sans extension):DN32:2314
In: Niveau 1
Type - Material: Laiton, Par défaut
Type - Autre(Type) - Catégorie: Accessoire de canalisation; Nom de la famille: BWT_Simply-connect (sans extension)
Type - Données d'identification(Type) - Fabricant: BWT; Modèle: Simply connect sans extension; Nom du type: DN32
Type - Données(Type) - BWT_DN de raccordement: 32 mm
Pset_ManufacturerTypeInformation - Manufacturer: BWT
Pset_DistributionFlowElementCommon - Reference: DN32
Autre - Catégorie: Accessoire de canalisation; Famille: BWT_Simply-connect (sans extension): DN32; Famille et type: BWT_Simply-connect (sans extension): DN32; ID du type: BWT_Simply-connect (sans extension): DN32; Type: BWT_Simply-connect (sans extension): DN32
Contraintes - Niveau: Niveau: Niveau 1; Décalage: 1300 mm; Hôte: Niveau : Niveau 1
Cotes - Surface: 0.0754028 m2; Taille: 32 mmø-32 mmø-32 mmø-32 mmø; Taille maximale: 32 mm; Taille minimale: 32 mm; Volume: 0.00122587 m3
Données d'identification - Identifiant: 1
Génie climatique - Type de système: Système de canalisation: Eau froide sanitaire; Classification du système: Eau froide sanitaire; Nom du système: Eau froide sanitaire 1
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 32 mmø-32 mmø-32 mmø-32 mmø
Phase de construction - Phase de création: Nouvelle construction
Group: Eau froide sanitaire 1

# IfcFlowSegment: Canalisation souple arrondie:Souple - Circulaire (2)
In: Niveau 1
Autre - Catégorie: Canalisation souple; Famille: Canalisation souple arrondie: Souple - Circulaire; Famille et type: Canalisation souple arrondie: Souple - Circulaire; ID du type: Canalisation souple arrondie: Souple - Circulaire; Type: Canalisation souple arrondie: Souple - Circulaire; sets with these values: 2
Contraintes - Niveau de référence: Niveau: Niveau 1
Cotes - Diamètre extérieur: 32 mm; Diamètre intérieur: 32 mm; sets with these values: 2
Données d'identification - sets with these values: 2
Génie climatique - Type de système: Système de canalisation: Eau froide sanitaire; Classification du système: Eau froide sanitaire; Diamètre: 32 mm; Nom du système: Eau froide sanitaire 1
Génie climatique - Ecoulement - Etat du flux: Laminaire; Facteur de frottement: 0; Flux: 0 m3/s; Flux supplémentaire: 0 m3/s; Frottement: 0; Nombre de Reynolds: 0; Perte de charge: 0 Pa; Rugosité relative: 0.00142875; Unités du dispositif: 0; Vitesse: 0 m/s
Graphismes - Modèle de gaine flexible: A voie unique; sets with these values: 2
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 32 mmø; sets with these values: 2
Phase de construction - Phase de création: Nouvelle construction; sets with these values: 2
Pset_DistributionFlowElementCommon - Reference: Souple - Circulaire
Autre(Type) - Catégorie: Canalisation souple; Nom de la famille: Canalisation souple arrondie
Données d'identification(Type) - Nom du type: Souple - Circulaire
Génie climatique(Type) - Rugosité: 0.04572 mm
Raccords(Type) - Té: Té - Générique: Standard; Transition: Transformation - Générique: Standard; Type de jonction préférée: Té; Union: Manchon - Générique: Standard
Group: Eau froide sanitaire 1
Name (Canalisation souple arrondie:Souple - Circulaire:...) | Décalage de départ (mm) | Longueur (mm) | Identifiant | Coupe
2315 | 1134.83 | 511.637 | 49 | 1
2317 | 1067.6 | 518.947 | 50 | 3 | Contraintes - sets with these values: 2; Génie climatique - Ecoulement - sets with these values: 2

# IfcFlowSegment: Canalisation:Standard (2)
In: Niveau 1
Autre - Catégorie: Canalisation; Famille: Canalisation: Standard; Famille et type: Canalisation: Standard; ID du type: Canalisation: Standard; Type: Canalisation: Standard; sets with these values: 2
Contraintes - Niveau de référence: Niveau: Niveau 1; Décalage de départ: 1300 mm; Décalage extrémité: 1300 mm; Décaler: 1300 mm; Inclinaison: 0; Justification horizontale: Centre; Justification verticale: Milieu
Cotes - Diamètre extérieur: 42.164 mm; Diamètre intérieur: 35.052 mm; Longueur: 300 mm; Taille: 32 mmø; sets with these values: 2
Données d'identification - sets with these values: 2
Génie climatique - Type de système: Système de canalisation: Eau froide sanitaire; Classification du système: Eau froide sanitaire; Diamètre: 32 mm; Inverser l'élévation: 1282.47 mm; Matériau: Acier, carbone; Nom du système: Eau froide sanitaire 1; Nomenclature/type: Types de nomenclatures de canalisations: Nomenclature 40; Rugosité: 0.04572 mm; Segment de canalisation: Acier au carbone - Série 40; Surface: 0.0301593 m2; Type de connexion: Générique
Génie climatique - Ecoulement - Etat du flux: Laminaire; Facteur de frottement: 0; Frottement: 0; Nombre de Reynolds: 0; Unités du dispositif: 0; Flux: 0 m3/s; Flux supplémentaire: 0 m3/s; Perte de charge: 0 Pa; Rugosité relative: 0.00130435; Vitesse: 0 m/s; sets with these values: 2
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 32 mmø; sets with these values: 2
Phase de construction - Phase de création: Nouvelle construction; sets with these values: 2
Pset_DistributionFlowElementCommon - Reference: Standard
Autre(Type) - Catégorie: Canalisation; Nom de la famille: Canalisation
Données d'identification(Type) - Nom du type: Standard
Group: Eau froide sanitaire 1
Name (Canalisation:Standard:...) | Identifiant | Coupe
2319 | 302 | 4
2321 | 303 | 2 | Contraintes - sets with these values: 2

# IfcFlowTerminal: RONDOMAT ECOBIO 3, BWT_ECOBIO 2 -3:RONDOMAT ECOBIO 3:2312
In: Niveau 1
Material: Stratifié, bleu marine, Plastique ABS, Plastique, noir opaque, Cuivre, Acier, moulé, Plastique, blanc opaque, Metal bleu; Group: Eau froide sanitaire 1
Pset_ManufacturerTypeInformation - Manufacturer: BWT_FRANCE
Pset_DistributionFlowElementCommon - Reference: RONDOMAT ECOBIO 3
Autre - Catégorie: Appareils sanitaires; Famille: BWT_ECOBIO 2 -3: RONDOMAT ECOBIO 3; Famille et type: BWT_ECOBIO 2 -3: RONDOMAT ECOBIO 3; ID du type: BWT_ECOBIO 2 -3: RONDOMAT ECOBIO 3; Type: BWT_ECOBIO 2 -3: RONDOMAT ECOBIO 3
Contraintes - Décalage: 0 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1
Cotes - Surface: 2.44599 m2; Volume: 0.253818 m3
Données - BWT_URL_Produit: http://www.bwt.fr/fr/Documentations/Eau_dconsommation_Humaine/Adoucissement/Pages/default.aspx
Données d'identification - Identifiant: 22
Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau froide sanitaire 1; Type de système: Système de canalisation: Eau froide sanitaire
Phase de construction - Phase de création: Nouvelle construction
Autre(Type) - Catégorie: Appareils sanitaires; BWT_Ecart_Simply_connect: 700 mm; BWT_Hauteur_Simply_Connect: 1700 mm; BWT_Hauteur cylindre: 480 mm; BWT_Hauteur de raccordment: 1130 mm; BWT-Hauteur socle: 146 mm; BWT-Hauteur socle ecran de contrôle: 38.4 mm; Nom de la famille: BWT_ECOBIO 2 -3
Cotes(Type) - BWT_Diamètre: 270 mm; BWT_Hauteur: 1400 mm; BWT_Hauteur bac à sel: 630 mm; BWT_Hauteur bouteille: 1060 mm; BWT_Largeur bac à sel: 470 mm
Données d'identification(Type) - Description: Adoucisseur; Fabricant: BWT_FRANCE; Modèle: ECOBIO 3; Nom du type: RONDOMAT ECOBIO 3; URL: http:\\www.bwt.fr
Données(Type) - BWT_ACS: no; BWT_Capacité bac à sel: 75; BWT_Capacité d'échange (°f.m3): 170; BWT_CODE: BK0RONDO3SC; BWT_Consommation électrique en regénération: 20 W; BWT_Débit à TH0° F: 0.0294289 m3/s; BWT_Débit eau de rejet: 0.00490481 m3/s; BWT_DN de raccordement: 32 mm; BWT_Masse en service: 280; BWT_Origine France Garantie: no; BWT_Pression maximum: 800000 Pa; BWT_Pression minimum: 250000 Pa; BWT_Température maxi eau: 30 kg/K/s3; BWT_Température max local: 40 kg/K/s3; BWT_Température mini eau: 5 kg/K/s3; BWT_Température min local: 5 kg/K/s3; BWT_Tension électrique: 230 V
Visibilité(Type) - Visilibité simply connect: yes

# IfcSystem: Eau froide sanitaire, Eau froide sanitaire 1
Autre - Catégorie: Système de canalisation; Famille: Système de canalisation: Eau froide sanitaire; Famille et type: Système de canalisation: Eau froide sanitaire; ID du type: Système de canalisation: Eau froide sanitaire; Type: Système de canalisation: Eau froide sanitaire
Génie climatique - Unités du dispositif: 0; Nombre d'éléments: 1; Nom du système: Eau froide sanitaire 1; Volume: 0.00177099 m3
Génie climatique - Ecoulement - Flux: 0 m3/s
