Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2017-03-22T12:00:01
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.5.0.0 - Interface alternative d'export 16.5.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 22 12:00:01 2017 * Host: LTBATREI25067 * Database: C:\Users\Blond\AppData\Local\Temp\{13A252DC-1C53-45DC-8ACB-75D201F3477F}\ifc * Database version: 5507 * Database creation date: Wed Mar 22 12:00:00 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 22 12:00:00 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 22 12:00:00 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 52, 0, 117187; RefLongitude: 2, 19, 59, 880409; RefElevation: 0 mm
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Centre; Symbole: Marqueur de niveau - Cercle: Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Pointe 8 mm
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Autre - Catégorie: Niveaux; Famille: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; ID du type: Niveau: Pointe 8 mm; Type: Niveau: Pointe 8 mm
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no

# IfcFlowTerminal: Clarificateur 21/50, BWT_filtre Clarificateur 21-50 Groupe:Clarificateur 21/50:176672
In: Niveau 1
Material: BWT_Noir, BWT_Laiton, BWT_Plastique blanc, INOX, Stratifié, bleu marine, BWT_Plastique rouge
Données(Type) - BWT_CODE: P0003640; BWT_DN de raccordement: 80 mm; BWT_Element filtrant: poche; BWT_Matériau: Acier inoxydable; BWT_Pression maximum: 1000000 Pa; BWT_Seuil de filtration: 20 µm; BWT_Température maxi eau: 85 kg/K/s3; BWT_Température max local: 30 kg/K/s3; BWT_Température mini eau: 30 kg/K/s3; BWT_Température min local: 5 kg/K/s3; BWT_Tension électrique: 230 V; BWT_Type de raccordement: brides
Données d'identification(Type) - Description: Filtre; Fabricant: BWT; Modèle: Clarificateur 21/50 Solutech; Nom du type: Clarificateur 21/50; URL: http:\\www.bwt.fr
Pset_ManufacturerTypeInformation - Manufacturer: BWT
Pset_DistributionFlowElementCommon - Reference: Clarificateur 21/50
Autre - Catégorie: Appareils sanitaires; Famille: BWT_filtre Clarificateur 21-50 Groupe: Clarificateur 21/50; Famille et type: BWT_filtre Clarificateur 21-50 Groupe: Clarificateur 21/50; ID du type: BWT_filtre Clarificateur 21-50 Groupe: Clarificateur 21/50; Type: BWT_filtre Clarificateur 21-50 Groupe: Clarificateur 21/50
Contraintes - Décalage: 0 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1
Cotes - Surface: 0.978935 m2; Volume: 0.0498688 m3
Données d'identification - Identifiant: 10
Génie climatique - Classification du système: Aération,Eau froide sanitaire
Phase de construction - Phase de création: Phase 1
Autre(Type) - Catégorie: Appareils sanitaires; Nom de la famille: BWT_filtre Clarificateur 21-50 Groupe
Cotes(Type) - BWT_Hauteur: 1508 mm; BWT_Largeur: 480 mm; BWT_Profondeur: 1320 mm
