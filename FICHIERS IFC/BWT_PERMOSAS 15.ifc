Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2017-06-30T11:29:01
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.5.0.0 - Interface alternative d'export 16.5.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jun 30 11:29:01 2017 * Host: LTBATREI25067 * Database: C:\Users\Blond\AppData\Local\Temp\{869268F3-5C15-41F3-9896-168B4A055512}\ifc * Database version: 5507 * Database creation date: Fri Jun 30 11:29:00 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jun 30 11:29:00 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jun 30 11:29:00 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: BWT 4ème serie; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 52, 0, 117187; RefLongitude: 2, 19, 59, 880409; RefElevation: 0 mm
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: BWT 4ème serie; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: BWT 4ème serie; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Centre; Symbole: Marqueur de niveau - Cercle: Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Pointe 8 mm
Autre - Catégorie: Niveaux; Famille: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; ID du type: Niveau: Pointe 8 mm; Type: Niveau: Pointe 8 mm
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet

# IfcFlowTerminal: PERMOSAS 15, BWT_PERMOSAS 15:PERMOSAS 15:137508
In: Niveau 1
Material: BWT_Bleu marine, BWT_Plastique noir, BWT_Plastique rouge, BWT_Cuivre, BWT_Acier galvanisé, BWT_Plastique
Pset_ManufacturerTypeInformation - Manufacturer: BWT_FRANCE
Pset_DistributionFlowElementCommon - Reference: PERMOSAS 15
Autre - Catégorie: Appareils sanitaires; Famille: BWT_PERMOSAS 15: PERMOSAS 15; Famille et type: BWT_PERMOSAS 15: PERMOSAS 15; ID du type: BWT_PERMOSAS 15: PERMOSAS 15; Type: BWT_PERMOSAS 15: PERMOSAS 15
Contraintes - Décalage: 0 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1
Cotes - Surface: 0.286895 m2; Volume: 18.9882 dm3
Données d'identification - Identifiant: 4
Génie climatique - Classification du système: Autre,Eau froide sanitaire,Autre
Phase de construction - Phase de création: Phase 1
Autre(Type) - Catégorie: Appareils sanitaires; Nom de la famille: BWT_PERMOSAS 15
Cotes(Type) - BWT_Hauteur: 775 mm; BWT_Largeur: 530 mm; BWT_Profondeur: 200 mm
Données d'identification(Type) - Fabricant: BWT_FRANCE; Modèle: PERMOSAS 15; Nom du type: PERMOSAS 15; URL: http:\\www.bwt.fr
Données(Type) - BWT_CODE: P0002010; BWT_DN de raccordement: 20 mm; BWT_Masse en service (Vide): 16; BWT_Matériau: Acier noir; BWT_Pression maximum: 1000000 Pa; BWT_Température maxi eau: 70 kg/K/s3; BWT_Température max local: 40 kg/K/s3; BWT_Température mini eau: 5 kg/K/s3; BWT_Température min local: 5 kg/K/s3; BWT_Type de raccordement: taraudé; BWT_Volume réservoir: 15 dm3
Matériaux et finitions(Type) - Matériau: BWT_Acier galvanisé; Matériau logo: BWT_Plastique
