Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2017-03-22T16:08:39
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.5.0.0 - Interface alternative d'export 16.5.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 22 16:08:39 2017 * Host: LTBATREI25067 * Database: C:\Users\Blond\AppData\Local\Temp\{15BF248F-D83C-4011-93CD-46B3C98F2FE0}\ifc * Database version: 5507 * Database creation date: Wed Mar 22 16:08:39 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 22 16:08:39 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 22 16:08:39 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: BWT 3eme Serie

# IfcSite, Default
RefLatitude: 48, 51, 23, 807373; RefLongitude: 2, 21, 7, 999076; RefElevation: 0 mm
Autre - Catégorie: Informations sur le projet; Nom du client: BWT; Nom du projet: BWT 3eme Serie; Numéro de projet: 0001

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Nom du client: BWT; Nom du projet: BWT 3eme Serie; Numéro de projet: 0001

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Plein; Symbole: Marqueur de niveau - Cercle: Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Pointe 8 mm
Autre - Catégorie: Niveaux; Famille: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; ID du type: Niveau: Pointe 8 mm; Type: Niveau: Pointe 8 mm
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 0; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet

# IfcFlowTerminal: Permaq Compact 20 Off-line, BWT_Permaq compact 20:Permaq Compact 20 Off-line:767190
In: Niveau 0
Material: BWT_Ecran, BWT_Plastique gris, BWT_Plastique noir, BWT_Plastique jaune, BWT_Plastique rouge, BWT_Laiton, BWT_Plastique blanc, Stratifié, bleu marine, Plastique ABS, BWT_Acier
Pset_ManufacturerTypeInformation - Manufacturer: BWT_FRANCE
Pset_DistributionFlowElementCommon - Reference: Permaq Compact 20 Off-line
Autre - Catégorie: Appareils sanitaires; Famille: BWT_Permaq compact 20: Permaq Compact 20 Off-line; Famille et type: BWT_Permaq compact 20: Permaq Compact 20 Off-line; ID du type: BWT_Permaq compact 20: Permaq Compact 20 Off-line; Type: BWT_Permaq compact 20: Permaq Compact 20 Off-line
Contraintes - Décalage: 0 mm; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0
Cotes - Surface: 2.07596 m2; Volume: 0.185067 m3
Données d'identification - Identifiant: 43
Génie climatique - Classification du système: Non défini,Autre
Phase de construction - Phase de création: Nouvelle construction
Autre(Type) - Catégorie: Appareils sanitaires; Nom de la famille: BWT_Permaq compact 20; Visibilité capot: yes
Cotes(Type) - BWT_DN raccordement condensat: 13 mm; BWT_Hauteur: 840 mm; BWT_Largeur: 400 mm; BWT_Profondeur: 670 mm; Ecart roue arrière: 250 mm; Ecart roue avant: 120 mm
Données d'identification(Type) - Description: Osmoseur; Fabricant: BWT_FRANCE; Modèle: Permaq Compact 20 Off-line; Nom du type: Permaq Compact 20 Off-line; URL: http:\\www.bwt.fr
Données(Type) - BWT_CODE: P0004517; BWT_Consommation électrique normale: 850 W; BWT_Débit perméat 10°C: 0.0000721667 m3/s; BWT_DN de raccordement: 20 mm; BWT_Masse en service (Vide): 95; BWT_Pression max eau alimentation: 600000 Pa; BWT_Pression min eau alimentation: 250000 Pa; BWT_Température maxi eau: 30 kg/K/s3; BWT_Température max local: 40 kg/K/s3; BWT_Température mini eau: 5 kg/K/s3; BWT_Température min local: 5 kg/K/s3; BWT_Tension électrique: 400 V; BWT_Volume réservoir perméat: 0 m3
Matériaux et finitions(Type) - Matériau 1: BWT_Plastique blanc; Matériau 2: BWT_Plastique noir; Matériau 3: BWT_Plastique gris; Matériau 4: BWT_Ecran; Matériau 5: BWT_Acier; Matériau 6: BWT_Plastique rouge; Matériau 7: BWT_Laiton; Matériau 8: BWT_Plastique jaune
