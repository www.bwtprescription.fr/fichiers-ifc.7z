Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2017-03-30T13:47:05
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.5.0.0 - Interface alternative d'export 16.5.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Mar 30 13:47:05 2017 * Host: LTBATREI25067 * Database: C:\Users\Blond\AppData\Local\Temp\{D5C02A2E-33D1-4991-8CB4-7740FB0A2570}\ifc * Database version: 5507 * Database creation date: Thu Mar 30 13:47:04 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Mar 30 13:47:04 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Mar 30 13:47:04 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: C:\Users\Blond\Desktop\Export IFC-Filtre-Groupe Solutech-BWT-170330\FR\Groupe solutech XS.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Autre - Catégorie: Informations sur le projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Plein; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Niveau 1
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Autre - Catégorie: Niveaux; Famille: Niveau: Niveau 1; Famille et type: Niveau: Niveau 1; ID du type: Niveau: Niveau 1; Type: Niveau: Niveau 1
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no

# IfcDistributionPort (20)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
3 x InPort_2312
OutPort_2326
2 x OutPort_2321
2 x OutPort_2324
2 x InPort_2313
OutPort_2315
InPort_2314
OutPort_2317
InPort_2315
2 x OutPort_2319
InPort_2317
InPort_2323
InPort_2326
OutPort_2328

# IfcFlowController: Robinet de purge, Robinet de purge:Robinet de purge:2328
In: Niveau 1
Type - Material: BWT_Plastique rouge, BWT_Laiton
Type - Autre(Type) - Catégorie: Accessoire de canalisation; Nom de la famille: Robinet de purge
Type - Données d'identification(Type) - Description: Robinet de purge; Fabricant: BWT_FRANCE; Modèle: Robinet de Purge Groupe Solutech; Nom du type: Robinet de purge; URL: http:\\www.bwt.fr
Type - Données(Type) - BWT_DN de raccordement: 20 mm
Pset_ManufacturerTypeInformation - Manufacturer: BWT_FRANCE
Pset_DistributionFlowElementCommon - Reference: Robinet de purge
Autre - Catégorie: Accessoire de canalisation; Famille: Robinet de purge: Robinet de purge; Famille et type: Robinet de purge: Robinet de purge; ID du type: Robinet de purge: Robinet de purge; Type: Robinet de purge: Robinet de purge
Contraintes - Niveau: Niveau: Niveau 1; Décalage: 310.001 mm; Hôte: Niveau : Niveau 1
Cotes - Angle robinet: 90 deg; Surface: 0.00669471 m2; Taille: 20 mmø-20 mmø; Taille maximale: 20 mm; Taille minimale: 20 mm; Volume: 0.0000704413 m3
Données d'identification - Identifiant: 69
Génie climatique - Classification du système: Eau froide sanitaire
Graphismes - Utiliser l'échelle d'annotations: no
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 20 mmø-20 mmø
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowController: Siriux 32-65F, Salmson PRIUX80-32:Siriux 32-65F:2313
In: Niveau 1
Type - Material: SS_Plastique rouge, SS_Plastique noir, SS_Plastique blanc, SS_plastique gris
Type - Autre(Type) - Catégorie: Accessoire de canalisation; Nom de la famille: Salmson PRIUX80-32
Type - Données d'identification(Type) - Description: Pompe de circulation; Fabricant: Salmson; Modèle: PRIUX 80-32; Nom du type: Siriux 32-65F; Numéro OmniClass: 23.60.10.17; Titre OmniClass: Flow Meters
Type - Données(Type) - BWT_DN de raccordement: 32 mm
Pset_ManufacturerTypeInformation - Manufacturer: Salmson
Pset_DistributionFlowElementCommon - Reference: Siriux 32-65F
Autre - Catégorie: Accessoire de canalisation; Famille: Salmson PRIUX80-32: Siriux 32-65F; Famille et type: Salmson PRIUX80-32: Siriux 32-65F; ID du type: Salmson PRIUX80-32: Siriux 32-65F; Type: Salmson PRIUX80-32: Siriux 32-65F
Contraintes - Décalage: 510.062 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1
Cotes - Surface: 0.0812048 m2; Taille: 32 mmø-32 mmø; Taille maximale: 32 mm; Taille minimale: 32 mm; Volume: 0.00102501 m3
Données d'identification - Identifiant: 57
Génie climatique - Classification du système: Eau froide sanitaire
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 32 mmø-32 mmø
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowController: Vanne DN32 (2)
In: Niveau 1
Type - Material: BWT_Plastique rouge, BWT_Laiton
Type - Autre(Type) - Catégorie: Accessoire de canalisation; Nom de la famille: Vanne XS
Type - Cotes(Type) - Angle poignée: 90 deg
Type - Données d'identification(Type) - Description: Vanne générique; Fabricant: BWT; Modèle: Vanne; Nom du type: Vanne DN32; URL: http:\\www.bwt.fr
Type - Données(Type) - BWT_DN de raccordement: 32 mm
Pset_ManufacturerTypeInformation - Manufacturer: BWT
Pset_DistributionFlowElementCommon - Reference: Vanne DN32
Autre - Catégorie: Accessoire de canalisation; Famille: Vanne XS: Vanne DN32; Famille et type: Vanne XS: Vanne DN32; ID du type: Vanne XS: Vanne DN32; Type: Vanne XS: Vanne DN32
Contraintes - Niveau: Niveau: Niveau 1; Hôte: Niveau : Niveau 1
Cotes - Surface: 0.0121835 m2; Taille: 32 mmø-32 mmø; Taille maximale: 32 mm; Taille minimale: 32 mm; Volume: 0.000152237 m3
Génie climatique - Classification du système: Eau froide sanitaire
Graphismes - Utiliser l'échelle d'annotations: no
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 32 mmø-32 mmø
Phase de construction - Phase de création: Nouvelle construction
Name (Vanne XS:Vanne DN32:...) | Décalage (mm) | Identifiant
2314 | 364.999 | 58
2323 | 309.999 | 59

# IfcFlowFitting: Standard, Coude - Générique:Standard:2319
In: Niveau 1
Type - Autre(Type) - Catégorie: Raccords de canalisation; Nom de la famille: Coude - Générique; Nom de la table de consultation: Elbow - Generic
Type - Données d'identification(Type) - Nom du type: Standard
Type - Génie climatique(Type) - Méthode de perte de charge: Coefficient K à partir du tableau; Tableau de coefficient K: Regular 45, 90 and 180 Elbow
Pset_DistributionFlowElementCommon - Reference: Standard
Autre - Catégorie: Raccords de canalisation; Famille: Coude - Générique: Standard; Famille et type: Coude - Générique: Standard; ID du type: Coude - Générique: Standard; Libellé de centre à extrémité: 32 mm; Rayon du centre: 32 mm; Rayon extérieur du raccord: 21.1 mm; Type: Coude - Générique: Standard
Contraintes - Niveau: Niveau: Niveau 1; Décalage: 364.999 mm; Hôte: Niveau : Niveau 1
Cotes - Angle: 90 deg; Centre à extrémité: 32 mm; Diamètre extérieur du raccord: 42.2 mm; Diamètre nominal: 32 mm; Rayon nominal: 16 mm; Taille: 32 mmø-32 mmø; Taille de la coche: 16.88 mm; Taille maximale: 32 mm; Taille minimale: 32 mm; Volume: 0.0000703026 m3
Données d'identification - Identifiant: 16
Génie climatique - Classification du système: Eau froide sanitaire
Graphismes - Utiliser l'échelle d'annotations: no
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 32 mmø-32 mmø
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowSegment: Canalisation:Standard (5)
In: Niveau 1
Autre - Catégorie: Canalisation; Famille: Canalisation: Standard; Famille et type: Canalisation: Standard; ID du type: Canalisation: Standard; Type: Canalisation: Standard; sets with these values: 2
Contraintes - Justification horizontale: Centre; Justification verticale: Milieu; Niveau de référence: Niveau: Niveau 1
Cotes - sets with these values: 2
Données d'identification - sets with these values: 2
Génie climatique - Classification du système: Non défini; Coupe: 1; Matériau: Acier, carbone; Nomenclature/type: Types de nomenclatures de canalisations: Nomenclature 40; Rugosité: 0.04572 mm; Segment de canalisation: Acier au carbone - Série 40; Type de connexion: Générique
Génie climatique - Ecoulement - Etat du flux: Laminaire; Facteur de frottement: 0; Flux: 0 m3/s; Flux supplémentaire: 0 m3/s; Frottement: 0; Nombre de Reynolds: 0; Perte de charge: 0 Pa; Unités du dispositif: 0; Vitesse: 0 m/s
Isolation - Epaisseur d'isolation: 0 mm; sets with these values: 2
Phase de construction - Phase de création: Nouvelle construction; sets with these values: 2
Pset_DistributionFlowElementCommon - Reference: Standard
Données d'identification(Type) - Nom du type: Standard
Autre(Type) - Catégorie: Canalisation; Nom de la famille: Canalisation
Name (Canalisation:Standard:...) | Décalage de départ (mm) = Décaler (mm) | Décalage extrémité (mm) | Diamètre extérieur (mm) | Diamètre intérieur (mm) | Longueur (mm) | Taille = Taille globale | Identifiant | Diamètre (mm) | Inverser l'élévation (mm) | Surface (m2) | Rugosité relative | Inclinaison | Génie climatique, sets with these values = Génie climatique - Ecoulement, sets with these values | Contraintes, sets with these values
2315 | 419.963 | 396.999 | 42.164 | 35.052 | 22.9635 | 32 mmø | 117 | 32 | 396.999 | 0.00230855 | 0.00130435
2317 | 364.999 | 364.999 | 42.164 | 35.052 | 4.02354 | 32 mmø | 118 | 32 | 347.473 | 0.000404491 | 0.00130435 | 0 | 2
2321 | 603.148 | 600.162 | 42.164 | 35.052 | 2.98589 | 32 mmø | 120 | 32 | 600.162 | 0.000300174 | 0.00130435 |  | 2 | 2
2324 | 309.999 | 309.999 | 42.164 | 35.052 | 3.72669 | 32 mmø | 122 | 32 | 292.473 | 0.000374648 | 0.00130435 | 0 | 2 | 2
2326 | 309.999 | 310 | 26.67 | 20.9296 | 3.11132 | 20 mmø | 127 | 20 | 299.534 | 0.00019549 | 0.00218447 | 0 | 2 | 2

# IfcFlowTerminal: Clarificateur XS, BWT_filtre Clarificateur XS Groupe:Clarificateur XS:2312
In: Niveau 1
Material: BWT_Noir, BWT_Laiton, BWT_Plastique blanc, INOX, BWT_Plastique rouge, Stratifié, bleu marine
Pset_ManufacturerTypeInformation - Manufacturer: BWT
Pset_DistributionFlowElementCommon - Reference: Clarificateur XS
Autre - Catégorie: Appareils sanitaires; Famille: BWT_filtre Clarificateur XS Groupe: Clarificateur XS; Famille et type: BWT_filtre Clarificateur XS Groupe: Clarificateur XS; ID du type: BWT_filtre Clarificateur XS Groupe: Clarificateur XS; Type: BWT_filtre Clarificateur XS Groupe: Clarificateur XS
Contraintes - Décalage: 0 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1
Cotes - Surface: 0.293721 m2; Volume: 0.00679716 m3
Données d'identification - Identifiant: 69
Génie climatique - Classification du système: Aération,Eau froide sanitaire
Phase de construction - Phase de création: Nouvelle construction
Autre(Type) - Catégorie: Appareils sanitaires; Nom de la famille: BWT_filtre Clarificateur XS Groupe
Cotes(Type) - BWT_Hauteur: 902 mm; BWT_Largeur: 372 mm; BWT_Profondeur: 523 mm
Données d'identification(Type) - Description: Filtre; Fabricant: BWT; Modèle: Clarificateur XS Groupe Solutech; Nom du type: Clarificateur XS; URL: http:\\www.bwt.fr
Données(Type) - BWT_CODE: P0003884; BWT_DN de raccordement: 32 mm; BWT_Element filtrant: poche; BWT_Matériau: Acier inoxydable; BWT_Pression maximum: 1000000 Pa; BWT_Seuil de filtration: 20 µm; BWT_Température maxi eau: 85 kg/K/s3; BWT_Température max local: 30 kg/K/s3; BWT_Température mini eau: 30 kg/K/s3; BWT_Température min local: 5 kg/K/s3; BWT_Tension électrique: 230 V; BWT_Type de raccordement: brides
