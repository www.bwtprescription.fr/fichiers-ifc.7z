Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2017-06-30T11:28:30
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.5.0.0 - Interface alternative d'export 16.5.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jun 30 11:28:30 2017 * Host: LTBATREI25067 * Database: C:\Users\Blond\AppData\Local\Temp\{BAC08B87-533E-48E5-82BD-C9E850807CD8}\ifc * Database version: 5507 * Database creation date: Fri Jun 30 11:28:30 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jun 30 11:28:30 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jun 30 11:28:30 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: BWT 4ème serie; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 52, 0, 117187; RefLongitude: 2, 19, 59, 880409; RefElevation: 0 mm
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: BWT 4ème serie; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: BWT 4ème serie; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Centre; Symbole: Marqueur de niveau - Cercle: Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Pointe 8 mm
Autre - Catégorie: Niveaux; Famille: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; ID du type: Niveau: Pointe 8 mm; Type: Niveau: Pointe 8 mm
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet

# IfcFlowTerminal: LEBOY 900, BWT_LEBOY:LEBOY 900:133239
In: Niveau 1
Material: BWT_Plastique bleu, Plastique noir, Aluminium, anodisé bleu, Plastique PC/ABS, Verre opaque, Plastique blanc, Acier, BWT_Plastique blanc, Stratifié, bleu marine
Pset_ManufacturerTypeInformation - Manufacturer: BWT_FRANCE
Pset_DistributionFlowElementCommon - Reference: LEBOY 900
Autre - Catégorie: Appareils sanitaires; Famille: BWT_LEBOY: LEBOY 900; Famille et type: BWT_LEBOY: LEBOY 900; ID du type: BWT_LEBOY: LEBOY 900; Type: BWT_LEBOY: LEBOY 900
Contraintes - Décalage: 0 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1
Cotes - Surface: 3.52202 m2; Volume: 493.5 dm3
Données d'identification - Identifiant: 3
Génie climatique - Classification du système: Eau froide sanitaire
Phase de construction - Phase de création: Phase 1
Autre(Type) - Catégorie: Appareils sanitaires; Nom de la famille: BWT_LEBOY
Contraintes(Type) - Base: 160 mm; Demi-largeur: 460 mm; H: 783 mm; Hauteur Logo: 633 mm; Socle: 300 mm
Cotes(Type) - BWT_Hauteur: 1180 mm; BWT_Largeur: 920 mm; BWT_Profondeur: 920 mm
Données d'identification(Type) - Fabricant: BWT_FRANCE; Modèle: LE BOY 900; Nom du type: LEBOY 900; URL: http:\\www.bwt.fr
Données(Type) - BWT_CODE: PK0006049; BWT_Consommation électrique normale: 75 W; BWT_Débit maximal: 0.323718 m3/s; BWT_DN de raccordement: 50 mm; BWT_Element filtrant: sable; BWT_Masse en service: 0; BWT_Matériau: Fonte/plastique; BWT_Pression maximum: 200000 Pa; BWT_Température maxi eau: 28 kg/K/s3; BWT_Température max local: 35 kg/K/s3; BWT_Température mini eau: 1 kg/K/s3; BWT_Température min local: 5 kg/K/s3; BWT_Tension électrique: 230 V; BWT_Type de raccordement: taraudé
Matériaux et finitions(Type) - Matériau 1: BWT_Plastique bleu; Matériau 2: BWT_Plastique blanc; Matériau 3: BWT_Plastique blanc
