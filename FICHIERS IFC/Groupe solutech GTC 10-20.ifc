Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2017-03-30T13:47:03
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.5.0.0 - Interface alternative d'export 16.5.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Mar 30 13:47:03 2017 * Host: LTBATREI25067 * Database: C:\Users\Blond\AppData\Local\Temp\{1A6D07D9-4651-4ED0-8AFF-E843FDFC31DF}\ifc * Database version: 5507 * Database creation date: Thu Mar 30 13:47:01 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Mar 30 13:47:01 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Mar 30 13:47:01 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: C:\Users\Blond\Desktop\Export IFC-Filtre-Groupe Solutech-BWT-170330\FR\Groupe solutech GTC 10-20.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Autre - Catégorie: Informations sur le projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Plein; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Niveau 1
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Autre - Catégorie: Niveaux; Famille: Niveau: Niveau 1; Famille et type: Niveau: Niveau 1; ID du type: Niveau: Niveau 1; Type: Niveau: Niveau 1
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no

# IfcBuildingElementProxy: Coffret électrique, BWT_Boitier Electrique Type 1:Coffret électrique:2325
In: Niveau 1
Type - Material: BWT_Plastique gris, BWT_Plastique blanc, BWT_Plastique rouge, BWT_Plastique vert
Type - Autre(Type) - Catégorie: Equipement électrique; Nom de la famille: BWT_Boitier Electrique Type 1
Type - Données d'identification(Type) - Description: Coffret électrique; Fabricant: BWT; Nom du type: Coffret électrique; URL: http:\\www.bwt.fr
Pset_BuildingElementProxyCommon - Reference: Coffret électrique
Pset_ManufacturerTypeInformation - Manufacturer: BWT
Autre - Catégorie: Equipement électrique; Famille: BWT_Boitier Electrique Type 1: Coffret électrique; Famille et type: BWT_Boitier Electrique Type 1: Coffret électrique; ID du type: BWT_Boitier Electrique Type 1: Coffret électrique; Type: BWT_Boitier Electrique Type 1: Coffret électrique
Contraintes - Niveau: Niveau: Niveau 1; Décalage: 1000 mm; Hôte: Niveau : Niveau 1; Se déplace avec les éléments voisins: no
Cotes - Surface: 0.135699 m2; Volume: 0.00848808 m3
Données d'identification - Identifiant: 3
Electricité - Charges - Charge apparente - Phase A: 0 W; Charge apparente - Phase B: 0 W; Charge apparente - Phase C: 0 W; Charge totale connectée: 0 W; Demande de charge totale estimée: 0 W; Facteur de charge totale: 1
Phase de construction - Phase de création: Nouvelle construction

# IfcDistributionPort (8)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
2 x InPort_2312
2 x OutPort_2320
OutPort_2322
InPort_2319
InPort_2322
OutPort_2324

# IfcFlowController: DN 50 (2)
In: Niveau 1
Type - Material: BWT_Bleu Métal, BWT_Plastique noir
Type - Autre(Type) - Catégorie: Accessoire de canalisation; Nom de la famille: Check valve 10-20
Type - Données d'identification(Type) - Description: check valve; Nom du type: DN 50; Numéro OmniClass: 23.60.10.17; Titre OmniClass: Flow Meters
Type - Données(Type) - BWT_DN de raccordement: 50 mm
Type - Matériaux et finitions(Type) - Matériau 1: BWT_Plastique noir; Matériau 2: BWT_Bleu Métal
Pset_DistributionFlowElementCommon - Reference: DN 50
Autre - Catégorie: Accessoire de canalisation; Famille: Check valve 10-20: DN 50; Famille et type: Check valve 10-20: DN 50; ID du type: Check valve 10-20: DN 50; Type: Check valve 10-20: DN 50
Contraintes - Niveau: Niveau: Niveau 1; Hôte: Niveau : Niveau 1
Cotes - Angle manette: 90 deg; Surface: 0.0435696 m2; Taille: 50 mmø-50 mmø; Taille maximale: 50 mm; Taille minimale: 50 mm; Volume: 0.000492468 m3
Génie climatique - Classification du système: Eau froide sanitaire
Graphismes - Utiliser l'échelle d'annotations: no
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 50 mmø-50 mmø
Phase de construction - Phase de création: Nouvelle construction
Name (Check valve 10-20:DN 50:...) | Décalage (mm) | Identifiant
2318 | 338.608 | 80
2319 | 409.943 | 81

# IfcFlowController: Infinity M 2" 1/2, Salmson SIRIUX 50-80:Infinity M 2" 1/2:2313
In: Niveau 1
Type - Material: SS_Plastique noir, SS_plastique gris, SS_Plastique blanc, SS_Plastique rouge
Type - Autre(Type) - Catégorie: Accessoire de canalisation; Nom de la famille: Salmson SIRIUX 50-80
Type - Cotes(Type) - DN Raccordement: 50 mm
Type - Données d'identification(Type) - Description: Filtre; Fabricant: BWT; Modèle: Infinity A; Nom du type: Infinity M 2" 1/2; Numéro OmniClass: 23.60.10.17; Titre OmniClass: Flow Meters
Pset_ManufacturerTypeInformation - Manufacturer: BWT
Pset_DistributionFlowElementCommon - Reference: Infinity M 2" 1/2
Autre - Catégorie: Accessoire de canalisation; Famille: Salmson SIRIUX 50-80: Infinity M 2" 1/2; Famille et type: Salmson SIRIUX 50-80: Infinity M 2" 1/2; ID du type: Salmson SIRIUX 50-80: Infinity M 2" 1/2; Type: Salmson SIRIUX 50-80: Infinity M 2" 1/2
Contraintes - Décalage: 501.101 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1
Cotes - Surface: 0.460821 m2; Taille: 50 mmø-50 mmø; Taille maximale: 50 mm; Taille minimale: 50 mm; Volume: 0.00744087 m3
Données d'identification - Identifiant: 79
Génie climatique - Classification du système: Non défini
Graphismes - Utiliser l'échelle d'annotations: no
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 50 mmø-50 mmø
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowController: Robinet de purge, Robinet de purge:Robinet de purge:2324
In: Niveau 1
Type - Material: BWT_Plastique rouge, BWT_Laiton
Type - Autre(Type) - Catégorie: Accessoire de canalisation; Nom de la famille: Robinet de purge
Type - Données d'identification(Type) - Description: Robinet de purge; Fabricant: BWT_FRANCE; Modèle: Robinet de Purge Groupe Solutech; Nom du type: Robinet de purge; URL: http:\\www.bwt.fr
Type - Données(Type) - BWT_DN de raccordement: 20 mm
Pset_ManufacturerTypeInformation - Manufacturer: BWT_FRANCE
Pset_DistributionFlowElementCommon - Reference: Robinet de purge
Autre - Catégorie: Accessoire de canalisation; Famille: Robinet de purge: Robinet de purge; Famille et type: Robinet de purge: Robinet de purge; ID du type: Robinet de purge: Robinet de purge; Type: Robinet de purge: Robinet de purge
Contraintes - Niveau: Niveau: Niveau 1; Décalage: 410.938 mm; Hôte: Niveau : Niveau 1
Cotes - Angle robinet: 90 deg; Surface: 0.00669471 m2; Taille: 20 mmø-20 mmø; Taille maximale: 20 mm; Taille minimale: 20 mm; Volume: 0.0000704413 m3
Données d'identification - Identifiant: 82
Génie climatique - Classification du système: Eau froide sanitaire
Graphismes - Utiliser l'échelle d'annotations: no
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 20 mmø-20 mmø
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowSegment: Canalisation:Par défaut (2)
In: Niveau 1
Autre - Catégorie: Canalisation; Famille: Canalisation: Par défaut; Famille et type: Canalisation: Par défaut; ID du type: Canalisation: Par défaut; Type: Canalisation: Par défaut; sets with these values: 2
Contraintes - Inclinaison: 0; Justification horizontale: Centre; Justification verticale: Milieu; Niveau de référence: Niveau: Niveau 1
Cotes - sets with these values: 2
Données d'identification - sets with these values: 2
Génie climatique - Classification du système: Non défini; Coupe: 1; Matériau: Acier au carbone; Nomenclature/type: Types de nomenclatures de canalisations: Nomenclature 40; Rugosité: 0.04572 mm; Segment de canalisation: Acier au carbone - Nomenclature 40; Type de connexion: Générique
Génie climatique - Ecoulement - Etat du flux: Laminaire; Facteur de frottement: 0; Flux: 0 m3/s; Flux supplémentaire: 0 m3/s; Frottement: 0; Nombre de Reynolds: 0; Perte de charge: 0 Pa; Unités du dispositif: 0; Vitesse: 0 m/s
Isolation - Epaisseur d'isolation: 0 mm; sets with these values: 2
Phase de construction - Phase de création: Nouvelle construction; sets with these values: 2
Pset_DistributionFlowElementCommon - Reference: Par défaut
Données d'identification(Type) - Nom du type: Par défaut
Autre(Type) - Catégorie: Canalisation; Nom de la famille: Canalisation
Name (Canalisation:Par défaut:...) | Décalage de départ (mm) = Décalage extrémité (mm) = Décaler (mm) | Diamètre extérieur (mm) | Diamètre intérieur (mm) | Longueur (mm) | Taille = Taille globale | Identifiant | Diamètre (mm) | Inverser l'élévation (mm) | Surface (m2) | Rugosité relative
2320 | 409.943 | 60.325 | 52.5018 | 6.94473 | 50 mmø | 133 | 50 | 383.692 | 0.00109088 | 0.000870827
2322 | 410.929 | 26.67 | 20.9296 | 3.7027 | 20 mmø | 134 | 20 | 400.464 | 0.000232647 | 0.00218447 | Contraintes - sets with these values: 2; Génie climatique - sets with these values: 2; Génie climatique - Ecoulement - sets with these values: 2

# IfcFlowTerminal: Clarificateur 10/20, BWT_filtre Clarificateur GTC 10-20 Groupe:Clarificateur 10/20:2312
In: Niveau 1
Material: BWT_Noir, BWT_Laiton, BWT_Plastique blanc, INOX, Stratifié, bleu marine, BWT_Plastique rouge
Pset_ManufacturerTypeInformation - Manufacturer: BWT
Pset_DistributionFlowElementCommon - Reference: Clarificateur 10/20
Autre - Catégorie: Appareils sanitaires; Famille: BWT_filtre Clarificateur GTC 10-20 Groupe: Clarificateur 10/20; Famille et type: BWT_filtre Clarificateur GTC 10-20 Groupe: Clarificateur 10/20; ID du type: BWT_filtre Clarificateur GTC 10-20 Groupe: Clarificateur 10/20; Type: BWT_filtre Clarificateur GTC 10-20 Groupe: Clarificateur 10/20
Contraintes - Décalage: 0.000497015 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1
Cotes - Surface: 0.596732 m2; Volume: 0.0272867 m3
Données - BWT_URL_Produit: http://www.bwt.fr/fr/Documentations/Eau_dconsommation_Humaine/Adoucissement/Pages/default.aspx
Données d'identification - Identifiant: 72
Génie climatique - Classification du système: Aération,Eau froide sanitaire
Phase de construction - Phase de création: Nouvelle construction
Autre(Type) - Catégorie: Appareils sanitaires; Nom de la famille: BWT_filtre Clarificateur GTC 10-20 Groupe
Cotes(Type) - BWT_Hauteur: 1011 mm; BWT_Largeur: 445 mm; BWT_Profondeur: 883 mm
Données d'identification(Type) - Description: Filtre; Fabricant: BWT; Modèle: Clarificateur 10/20 Solutech; Nom du type: Clarificateur 10/20; URL: http:\\www.bwt.fr
Données(Type) - BWT_CODE: P0003642; BWT_DN de raccordement: 50 mm; BWT_Element filtrant: poche; BWT_Matériau: Acier inoxydable; BWT_Pression maximum: 1000000 Pa; BWT_Seuil de filtration: 20 µm; BWT_Température maxi eau: 85 kg/K/s3; BWT_Température max local: 30 kg/K/s3; BWT_Température mini eau: 30 kg/K/s3; BWT_Température min local: 5 kg/K/s3; BWT_Tension électrique: 230 V; BWT_Type de raccordement: brides
