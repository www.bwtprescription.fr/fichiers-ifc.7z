Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2017-03-22T13:59:26
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.5.0.0 - Interface alternative d'export 16.5.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 22 13:59:26 2017 * Host: LTBATREI25067 * Database: C:\Users\Blond\AppData\Local\Temp\{2E4B4FBE-C451-4212-835A-B302A85FD694}\ifc * Database version: 5507 * Database creation date: Wed Mar 22 13:59:25 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 22 13:59:25 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 22 13:59:25 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: C:\Users\Blond\Desktop\Export IFC\Adouccisseur\FR\8400 SC.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Autre - Catégorie: Informations sur le projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Plein; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Niveau 1
Autre - Catégorie: Niveaux; Famille: Niveau: Niveau 1; Famille et type: Niveau: Niveau 1; ID du type: Niveau: Niveau 1; Type: Niveau: Niveau 1
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet

# IfcBuildingElementProxy: 1400 x 820 mm, BWT_Bac à sel type 2:1400 x 820 mm:2313
In: Niveau 1
Type - Material: Plastique PPS
Type - Autre(Type) - Catégorie: Modèles génériques; Nom de la famille: BWT_Bac à sel type 2
Type - Cotes(Type) - Diamètre: 820 mm; h1: 481 mm; Hauteur: 1400 mm
Type - Données d'identification(Type) - Description: Bac à sel; Fabricant: BWT; Nom du type: 1400 x 820 mm; URL: http:\\www.bwt.fr
Pset_BuildingElementProxyCommon - Reference: 1400 x 820 mm
Pset_ManufacturerTypeInformation - Manufacturer: BWT
Autre - Catégorie: Modèles génériques; Famille: BWT_Bac à sel type 2: 1400 x 820 mm; Famille et type: BWT_Bac à sel type 2: 1400 x 820 mm; ID du type: BWT_Bac à sel type 2: 1400 x 820 mm; Type: BWT_Bac à sel type 2: 1400 x 820 mm
Contraintes - Décalage: 0 mm; Niveau: Niveau: Niveau 1; Hôte: Niveau : Niveau 1; Se déplace avec les éléments voisins: no
Cotes - Surface: 2.29774 m2; Volume: 0.731958 m3
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowTerminal: 8400SC, BWT_8150SC-8300SC-8400SC:8400SC:2312
In: Niveau 1
Material: Stratifié, bleu marine, Plastique ABS, Plastique bleu, Acier, moulé, Plastique, noir opaque, Cuivre, Plastique, blanc opaque, Bouton Rouge
Pset_ManufacturerTypeInformation - Manufacturer: BWT_FRANCE
Pset_DistributionFlowElementCommon - Reference: 8400SC
Autre - Catégorie: Appareils sanitaires; Famille: BWT_8150SC-8300SC-8400SC: 8400SC; Famille et type: BWT_8150SC-8300SC-8400SC: 8400SC; ID du type: BWT_8150SC-8300SC-8400SC: 8400SC; Type: BWT_8150SC-8300SC-8400SC: 8400SC
Contraintes - Décalage: 0 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1
Cotes - Surface: 4.45787 m2; Volume: 0.896923 m3
Données - BWT_URL_Produit: http://www.bwt.fr/fr/Documentations/Eau_dconsommation_Humaine/Adoucissement/Pages/default.aspx
Données d'identification - Identifiant: 13
Génie climatique - Classification du système: Eau froide sanitaire
Phase de construction - Phase de création: Nouvelle construction
Autre(Type) - Catégorie: Appareils sanitaires; BWT_Ecart Logo: 350 mm; BWT_Hauteur cylindre: 480 mm; BWT_Hauteur de raccordment: 2250 mm; BWT_Hauteur Logo: 1100 mm; BWT-Hauteur socle: 307 mm; BWT-Hauteur socle ecran de contrôle: 38.4 mm; Nom de la famille: BWT_8150SC-8300SC-8400SC
Cotes(Type) - BWT_Diamètre: 770 mm; BWT_Hauteur: 2400 mm; BWT_Hauteur bac à sel: 1400 mm; BWT_Hauteur bouteille: 2065 mm; BWT_Largeur bac à sel: 820 mm
Données d'identification(Type) - Description: Adoucisseur; Fabricant: BWT_FRANCE; Nom du type: 8400SC; URL: http:\\www.bwt.fr
Données(Type) - BWT_ACS: yes; BWT_Capacité bac à sel: 600; BWT_Capacité d'échange (°f.m3): 2000-2320; BWT_CODE: BK000008400; BWT_Consommation électrique en regénération: 50 W; BWT_Consommation électrique normale: 10 W; BWT_Débit à TH0° F: 0.245241 m3/s; BWT_Débit eau de rejet: 0.0980963 m3/s; BWT_DN de raccordement: 65 mm; BWT_Masse en service (kg/m2): 3000-4000; BWT_Origine France Garantie: yes; BWT_Pression maximum: 700000 Pa; BWT_Pression minimum: 150000 Pa; BWT_Température maxi eau: 35 kg/K/s3; BWT_Température max local: 40 kg/K/s3; BWT_Température mini eau: 5 kg/K/s3; BWT_Température min local: 5 kg/K/s3; BWT_Tension électrique: 230 V; BWT_Volume de résine: 0.4 m3
Matériaux et finitions(Type) - Matériau 1: Plastique, noir opaque; Matériau 2: Plastique bleu; Matériau 3: Plastique, blanc opaque
Visibilité(Type) - Bac à sel: yes
