Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2017-03-22T16:03:23
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.5.0.0 - Interface alternative d'export 16.5.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 22 16:03:23 2017 * Host: LTBATREI25067 * Database: C:\Users\Blond\AppData\Local\Temp\{3147A2C2-AEE5-4597-ABC7-7E68AB38CD19}\ifc * Database version: 5507 * Database creation date: Wed Mar 22 16:03:22 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 22 16:03:23 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 22 16:03:23 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: BWT 3eme Serie

# IfcSite, Default
RefLatitude: 48, 51, 23, 807373; RefLongitude: 2, 21, 7, 999076; RefElevation: 0 mm
Autre - Catégorie: Informations sur le projet; Nom du client: BWT; Nom du projet: BWT 3eme Serie; Numéro de projet: 0001

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Nom du client: BWT; Nom du projet: BWT 3eme Serie; Numéro de projet: 0001

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Plein; Symbole: Marqueur de niveau - Cercle: Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Pointe 8 mm
Autre - Catégorie: Niveaux; Famille: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; ID du type: Niveau: Pointe 8 mm; Type: Niveau: Pointe 8 mm
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 0; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet

# IfcFlowTerminal: Groupe de dosage XGA, BWT_Groupe de dosage XGA:Groupe de dosage XGA:734713
In: Niveau 0
Material: Stratifié, bleu marine, Plastique ABS, Plastique, noir opaque, BWT_Plastique vert, Plastique, blanc opaque, BWT_Plastique
Pset_ManufacturerTypeInformation - Manufacturer: BWT_FRANCE
Pset_DistributionFlowElementCommon - Reference: Groupe de dosage XGA
Autre - Catégorie: Appareils sanitaires; Famille: BWT_Groupe de dosage XGA: Groupe de dosage XGA; Famille et type: BWT_Groupe de dosage XGA: Groupe de dosage XGA; ID du type: BWT_Groupe de dosage XGA: Groupe de dosage XGA; Type: BWT_Groupe de dosage XGA: Groupe de dosage XGA
Contraintes - Décalage: 0 mm; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0; Se déplace avec les éléments voisins: no
Cotes - Surface: 2.69397 m2; Volume: 0.213148 m3
Données d'identification - Identifiant: 10
Phase de construction - Phase de création: Nouvelle construction
Autre(Type) - Catégorie: Appareils sanitaires; Nom de la famille: BWT_Groupe de dosage XGA
Cotes(Type) - BWT_Hauteur: 1351 mm; BWT_Largeur: 600 mm; BWT_Profondeur: 600 mm
Données d'identification(Type) - Fabricant: BWT_FRANCE; Modèle: Groupe de dosage XGA; Nom du type: Groupe de dosage XGA; URL: http:\\www.bwt.fr
Données(Type) - BWT_CODE: PK0027108C; BWT_Consommation électrique normale: 24 W; BWT_Débit maximal à 3 bar: 0.00000233333 m3/s; BWT_Débit maximal à 7 bar: 0.000002 m3/s; BWT_Diamètre de raccordement: 4+9 mm; BWT_Masse en service (Vide): 18; BWT_Pression maximum: 1600000 Pa; BWT_Température maxi eau: 45 kg/K/s3; BWT_Température max local: 45 kg/K/s3; BWT_Température mini eau: 0 kg/K/s3; BWT_Température min local: 0 kg/K/s3; BWT_Tension électrique: 230 V; BWT_Volume réservoir: 0.14 m3
Matériaux et finitions(Type) - Matériau 1: BWT_Plastique
