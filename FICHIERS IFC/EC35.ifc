Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2017-03-22T13:54:45
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.5.0.0 - Interface alternative d'export 16.5.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 22 13:54:45 2017 * Host: LTBATREI25067 * Database: C:\Users\Blond\AppData\Local\Temp\{22DBB0D5-4684-4757-BF78-14ABC9C2FF46}\ifc * Database version: 5507 * Database creation date: Wed Mar 22 13:54:45 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 22 13:54:45 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 22 13:54:45 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: C:\Users\Blond\Desktop\Export IFC\Adouccisseur\FR\EC35.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Autre - Catégorie: Informations sur le projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Plein; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Niveau 1
Autre - Catégorie: Niveaux; Famille: Niveau: Niveau 1; Famille et type: Niveau: Niveau 1; ID du type: Niveau: Niveau 1; Type: Niveau: Niveau 1
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet

# IfcBuildingElementProxy: 775 x 535 mm, BWT_Bac à sel type 1:775 x 535 mm:2313
In: Niveau 1
Type - Material: Plastique PPS
Type - Autre(Type) - Catégorie: Modèles génériques; Nom de la famille: BWT_Bac à sel type 1
Type - Cotes(Type) - Diamètre: 535 mm; Hauteur: 775 mm
Type - Données d'identification(Type) - Description: Bac à sel; Fabricant: BWT; Nom du type: 775 x 535 mm; URL: http:\\www.bwt.fr
Pset_BuildingElementProxyCommon - Reference: 775 x 535 mm
Pset_ManufacturerTypeInformation - Manufacturer: BWT
Autre - Catégorie: Modèles génériques; Famille: BWT_Bac à sel type 1: 775 x 535 mm; Famille et type: BWT_Bac à sel type 1: 775 x 535 mm; ID du type: BWT_Bac à sel type 1: 775 x 535 mm; Type: BWT_Bac à sel type 1: 775 x 535 mm
Contraintes - Décalage: 0 mm; Niveau: Niveau: Niveau 1; Hôte: Niveau : Niveau 1; Se déplace avec les éléments voisins: no
Cotes - Surface: 0.806107 m2; Volume: 0.156267 m3
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowTerminal: EC 35, BWT_EC:EC 35:2312
In: Niveau 1
Material: Acier, moulé, Plastique, blanc opaque, Cuivre, Plastique, noir opaque, Poignée rouge Acier, Metal bleu
Pset_ManufacturerTypeInformation - Manufacturer: BWT_FRANCE
Pset_DistributionFlowElementCommon - Reference: EC 35
Autre - Catégorie: Appareils sanitaires; Famille: BWT_EC: EC 35; Famille et type: BWT_EC: EC 35; ID du type: BWT_EC: EC 35; Type: BWT_EC: EC 35
Contraintes - Décalage: 0 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1
Cotes - Surface: 0.635584 m2; Volume: 0.0438342 m3
Données - BWT_URL_Produit: http://www.bwt.fr/fr/Documentations/Eau_dconsommation_Humaine/Adoucissement/Pages/default.aspx
Données d'identification - Identifiant: 18
Génie climatique - Classification du système: Eau froide sanitaire
Phase de construction - Phase de création: Nouvelle construction
Autre(Type) - Catégorie: Appareils sanitaires; BWT_Ecart Logo: 100 mm; BWT_Hauteur cylindre: 480 mm; BWT_Hauteur de raccordment: 927 mm; BWT_Hauteur Logo: 500 mm; BWT-Hauteur socle: 146 mm; BWT-Hauteur socle ecran de contrôle: 38.4 mm; Nom de la famille: BWT_EC
Cotes(Type) - BWT_Diamètre: 255 mm; BWT_Hauteur: 1085 mm; BWT_Hauteur bac à sel: 775 mm; BWT_Hauteur bouteille: 898.125 mm; BWT_Largeur bac à sel: 535 mm
Données d'identification(Type) - Description: Adoucisseur; Fabricant: BWT_FRANCE; Modèle: EC 35; Nom du type: EC 35; URL: http:\\www.bwt.fr
Données(Type) - BWT_ACS: no; BWT_Capacité bac à sel: 150; BWT_Capacité d'échange (°f.m3): 200; BWT_CODE: PK0001572; BWT_Débit à TH0° F: 0.0245241 m3/s; BWT_DN de raccordement: 25 mm; BWT_Masse en service: 180; BWT_Origine France Garantie: no; BWT_Pression maximum: 860000 Pa; BWT_Pression minimum: 200000 Pa; BWT_Température maxi eau: 65 kg/K/s3; BWT_Température max local: 40 kg/K/s3; BWT_Température mini eau: 5 kg/K/s3; BWT_Température min local: 5 kg/K/s3; BWT_Tension électrique: 230 V; BWT_Volume de résine: 0.035 m3
Matériaux et finitions(Type) - Matériau 3: Plastique, blanc opaque
Visibilité(Type) - Bac à sel Type 1: yes; Bac à sel Type 2: no; Visilibité simply connect: no
