Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2017-03-22T13:58:22
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.5.0.0 - Interface alternative d'export 16.5.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 22 13:58:22 2017 * Host: LTBATREI25067 * Database: C:\Users\Blond\AppData\Local\Temp\{D18B18EE-2B5D-4A28-8F6A-208DB970CBB1}\ifc * Database version: 5507 * Database creation date: Wed Mar 22 13:58:22 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 22 13:58:22 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 22 13:58:22 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: C:\Users\Blond\Desktop\Export IFC\Adouccisseur\FR\6075 SC.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Autre - Catégorie: Informations sur le projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Autre - Catégorie: Niveaux; Famille: Niveau: Niveau 1; Famille et type: Niveau: Niveau 1; ID du type: Niveau: Niveau 1; Type: Niveau: Niveau 1
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet
Données d'identification(Type) - Nom du type: Niveau 1
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Plein; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes

# IfcBuildingElementProxy: 780 x 530 mm, BWT_Bac à sel type 2:780 x 530 mm:2313
In: Niveau 1
Type - Material: Plastique PPS
Type - Autre(Type) - Catégorie: Modèles génériques; Nom de la famille: BWT_Bac à sel type 2
Type - Cotes(Type) - Diamètre: 530 mm; h1: 481 mm; Hauteur: 780 mm
Type - Données d'identification(Type) - Description: Bac à sel; Fabricant: BWT; Nom du type: 780 x 530 mm; URL: http:\\www.bwt.fr
Pset_BuildingElementProxyCommon - Reference: 780 x 530 mm
Pset_ManufacturerTypeInformation - Manufacturer: BWT
Autre - Catégorie: Modèles génériques; Famille: BWT_Bac à sel type 2: 780 x 530 mm; Famille et type: BWT_Bac à sel type 2: 780 x 530 mm; ID du type: BWT_Bac à sel type 2: 780 x 530 mm; Type: BWT_Bac à sel type 2: 780 x 530 mm
Contraintes - Décalage: 0 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1; Se déplace avec les éléments voisins: no
Cotes - Surface: 0.849103 m2; Volume: 0.167967 m3
Phase de construction - Phase de création: Nouvelle construction

# IfcDistributionPort (8)
Description: Flow; FlowDirection: SOURCEANDSINK
Name | Group
InPort_2314 | Eau froide sanitaire 1
OutPort_2315 | Eau froide sanitaire 1
InPort_2314 | Eau froide sanitaire 2
OutPort_2317 | Eau froide sanitaire 2
InPort_2314 | Eau froide sanitaire 3
OutPort_2319 | Eau froide sanitaire 3
InPort_2314 | Eau froide sanitaire 4
OutPort_2321 | Eau froide sanitaire 4

# IfcFlowController: Module By-pass, BWT_By-pass:Module By-pass:2314
In: Niveau 1
Type - Material: Laiton, Par défaut
Type - Autre(Type) - Catégorie: Accessoire de canalisation; Nom de la famille: BWT_By-pass
Type - Cotes(Type) - Rayon: 12.5 mm
Type - Données d'identification(Type) - Fabricant: BWT; Modèle: Module By-pass; Nom du type: Module By-pass
Type - Données(Type) - BWT_DN de raccordement: 25 mm
Pset_ManufacturerTypeInformation - Manufacturer: BWT
Pset_DistributionFlowElementCommon - Reference: Module By-pass
Autre - Catégorie: Accessoire de canalisation; Famille: BWT_By-pass: Module By-pass; Famille et type: BWT_By-pass: Module By-pass; ID du type: BWT_By-pass: Module By-pass; Type: BWT_By-pass: Module By-pass
Contraintes - Niveau: Niveau: Niveau 1; Décalage: 1599.97 mm; Hôte: Niveau : Niveau 1
Cotes - Surface: 0.0266484 m2; Taille: 25 mmø-25 mmø-25 mmø-25 mmø; Taille maximale: 25 mm; Taille minimale: 25 mm; Volume: 0.000262401 m3
Données d'identification - Identifiant: 167
Génie climatique - Classification du système: Eau froide sanitaire; Nom du système: Eau froide sanitaire 2,Eau froide sanitaire 1,Eau froide sanitaire 3,Eau froide sanitaire 4; Type de système: Système de canalisation: Eau froide sanitaire
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 25 mmø-25 mmø-25 mmø-25 mmø
Phase de construction - Phase de création: Nouvelle construction
Group: Eau froide sanitaire 1; Eau froide sanitaire 2; Eau froide sanitaire 3; Eau froide sanitaire 4

# IfcFlowSegment: Canalisation souple arrondie:Souple - Circulaire (2)
In: Niveau 1
Autre - Catégorie: Canalisation souple; Famille: Canalisation souple arrondie: Souple - Circulaire; Famille et type: Canalisation souple arrondie: Souple - Circulaire; ID du type: Canalisation souple arrondie: Souple - Circulaire; Type: Canalisation souple arrondie: Souple - Circulaire; sets with these values: 2
Contraintes - Niveau de référence: Niveau: Niveau 1; sets with these values: 2
Cotes - Diamètre extérieur: 25 mm; Diamètre intérieur: 25 mm; sets with these values: 2
Données d'identification - sets with these values: 2
Génie climatique - Type de système: Système de canalisation: Eau froide sanitaire; Coupe: 1; Classification du système: Eau froide sanitaire; Diamètre: 25 mm; sets with these values: 2
Génie climatique - Ecoulement - Etat du flux: Laminaire; Facteur de frottement: 0; Frottement: 0; Nombre de Reynolds: 0; Unités du dispositif: 0; Flux: 0 m3/s; Flux supplémentaire: 0 m3/s; Perte de charge: 0 Pa; Rugosité relative: 0.0018288; Vitesse: 0 m/s; sets with these values: 2
Graphismes - Modèle de gaine flexible: A voie unique; sets with these values: 2
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 25 mmø; sets with these values: 2
Phase de construction - Phase de création: Nouvelle construction; sets with these values: 2
Pset_DistributionFlowElementCommon - Reference: Souple - Circulaire
Autre(Type) - Catégorie: Canalisation souple; Nom de la famille: Canalisation souple arrondie
Données d'identification(Type) - Nom du type: Souple - Circulaire
Génie climatique(Type) - Rugosité: 0.04572 mm
Raccords(Type) - Té: Té - Générique: Standard; Transition: Transformation - Générique: Standard; Type de jonction préférée: Té; Union: Manchon - Générique: Standard
Name (Canalisation souple arrondie:Souple - Circulaire:...) | Décalage de départ (mm) | Longueur (mm) | Identifiant | Nom du système = Group
2319 | 1557.88 | 462.954 | 22 | Eau froide sanitaire 3
2321 | 1557.94 | 479.342 | 23 | Eau froide sanitaire 4

# IfcFlowSegment: Canalisation:Standard (2)
In: Niveau 1
Autre - Catégorie: Canalisation; Famille: Canalisation: Standard; Famille et type: Canalisation: Standard; ID du type: Canalisation: Standard; Type: Canalisation: Standard; sets with these values: 2
Contraintes - Décalage de départ: 1599.5 mm; Décalage extrémité: 1599.5 mm; Décaler: 1599.5 mm; Inclinaison: 0; Justification horizontale: Centre; Justification verticale: Milieu; Niveau de référence: Niveau: Niveau 1
Cotes - Diamètre extérieur: 33.401 mm; Diamètre intérieur: 26.6446 mm; Longueur: 200 mm; Taille: 25 mmø; sets with these values: 2
Données d'identification - sets with these values: 2
Génie climatique - Type de système: Système de canalisation: Eau froide sanitaire; Classification du système: Eau froide sanitaire; Coupe: 1; Diamètre: 25 mm; Inverser l'élévation: 1586.18 mm; Matériau: Acier, carbone; Nomenclature/type: Types de nomenclatures de canalisations: Nomenclature 40; Rugosité: 0.04572 mm; Segment de canalisation: Acier au carbone - Série 40; Surface: 0.015708 m2; Type de connexion: Générique
Génie climatique - Ecoulement - Etat du flux: Laminaire; Facteur de frottement: 0; Flux: 0 m3/s; Flux supplémentaire: 0 m3/s; Frottement: 0; Nombre de Reynolds: 0; Perte de charge: 0 Pa; Rugosité relative: 0.00171592; Unités du dispositif: 0; Vitesse: 0 m/s
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 25 mmø; sets with these values: 2
Phase de construction - Phase de création: Nouvelle construction; sets with these values: 2
Pset_DistributionFlowElementCommon - Reference: Standard
Autre(Type) - Catégorie: Canalisation; Nom de la famille: Canalisation
Données d'identification(Type) - Nom du type: Standard
Name (Canalisation:Standard:...) | Identifiant | Nom du système = Group
2315 | 238 | Eau froide sanitaire 1
2317 | 239 | Eau froide sanitaire 2 | Contraintes - sets with these values: 2; Génie climatique - sets with these values: 2; Génie climatique - Ecoulement - sets with these values: 2

# IfcFlowTerminal: 6075SC, BWT_6000SC:6075SC:2312
In: Niveau 1
Material: Plastique, noir opaque, Plastique, blanc opaque, Acier, moulé, Stratifié, bleu marine, UHMW, noir, INOX
Pset_ManufacturerTypeInformation - Manufacturer: BWT_FRANCE
Pset_DistributionFlowElementCommon - Reference: 6075SC
Autre - Catégorie: Appareils sanitaires; Famille: BWT_6000SC: 6075SC; Famille et type: BWT_6000SC: 6075SC; ID du type: BWT_6000SC: 6075SC; Type: BWT_6000SC: 6075SC
Contraintes - Décalage: 0 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1
Cotes - Surface: 1.39169 m2; Volume: 0.128142 m3
Données - BWT_URL_Produit: http://www.bwt.fr/fr/Documentations/Eau_dconsommation_Humaine/Pages/default.aspx
Données d'identification - Identifiant: 6
Génie climatique - Classification du système: Eau froide sanitaire
Phase de construction - Phase de création: Nouvelle construction
Autre(Type) - Catégorie: Appareils sanitaires; BWT_Hauteur cylindre: 480 mm; BWT_Hauteur de raccordment: 1465 mm; BWT_Logo ecart: 150 mm; BWT-Hauteur socle: 196 mm; BWT-Hauteur socle ecran de contrôle: 38.4 mm; Nom de la famille: BWT_6000SC
Cotes(Type) - BWT_Diamètre: 335 mm; BWT_Hauteur: 1830 mm; BWT_Hauteur bac à sel: 780 mm; BWT_Hauteur bouteille: 1415 mm; BWT_Largeur bac à sel: 530 mm
Données d'identification(Type) - Description: Adoucisseur; Fabricant: BWT_FRANCE; Nom du type: 6075SC; URL: http:\\www.bwt.fr
Données(Type) - BWT_ACS: yes; BWT_Capacité bac à sel: 100; BWT_Capacité d'échange (°f.m3): 300-375; BWT_CODE: BK06075SC32; BWT_Consommation électrique en regénération: 50 W; BWT_Consommation électrique normale: 10 W; BWT_Débit à TH0° F: 0.0294289 m3/s; BWT_Débit eau de rejet: 0.0107906 m3/s; BWT_DN de raccordement: 32 mm; BWT_Masse en service: 400; BWT_Origine France Garantie: yes; BWT_Pression maximum: 700000 Pa; BWT_Pression minimum: 150000 Pa; BWT_Température maxi eau: 35 kg/K/s3; BWT_Température max local: 40 kg/K/s3; BWT_Température mini eau: 5 kg/K/s3; BWT_Température min local: 5 kg/K/s3; BWT_Tension électrique: 230 V; BWT_Volume de résine: 0.075 m3

# IfcSystem: Eau froide sanitaire (4)
Autre - Catégorie: Système de canalisation; Famille: Système de canalisation: Eau froide sanitaire; Famille et type: Système de canalisation: Eau froide sanitaire; ID du type: Système de canalisation: Eau froide sanitaire; Type: Système de canalisation: Eau froide sanitaire
Génie climatique - Unités du dispositif: 0; Nombre d'éléments: 0
Génie climatique - Ecoulement - Flux: 0 m3/s
Name | Nom du système | Volume (m3)
Eau froide sanitaire 1 | Eau froide sanitaire 1 | 0.000149955
Eau froide sanitaire 2 | Eau froide sanitaire 2 | 0.000146818
Eau froide sanitaire 3 | Eau froide sanitaire 3 | 0.000247911
Eau froide sanitaire 4 | Eau froide sanitaire 4 | 0.000255926
